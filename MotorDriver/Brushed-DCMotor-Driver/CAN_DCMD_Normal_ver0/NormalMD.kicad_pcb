# Repository Atsuki3zuta/NHK_RC20_PCBs (continued)

## KiCad design Main/stm32f4_Centaurus_ver.3.1.1/stm32f4_Centaurus.kicad_pcb (continued)

Board: 2 copper layers, 100.0 x 79.0 mm, 232 parts (147 on the bottom side), 195 nets.

## KiCad design Power/Electricity_Manager_40W_ver.3.0/Electricity_Manager_40W.kicad_pcb

Parts:
AMP1, AMP2: TSC103; SO-8_3.9x4.9mm_P1.27mm
C1, C5: 22p; C_0603
C2, C3, C4, C6, C7, C8, C9, C10, C12, C14, C16, C17, C18, C19, C22, C23, C27, C29, C30, C33, C34, C38, C41, C44, C47, C48: 0.1u; C_0603
C11, C13: 2.2u; C_0603
C15, C20, C21, C25, C42, C43: 1u; C_0603
C24, C26, C28, C46, C49: 10u; C_0603
C31: 4.7u; C_0603
C32: 220u; CP_Radial_D8.0mm_P2.50mm
C35: 470u; CP_Radial_D8.0mm_P3.50mm
C36: 1500p; C_0603
C37: 1u; C_0805
D1, D9, D11, D12, D13, D21, D22, D23, D24, D25, D29: DIODE; SOD-123
D2: 12V; LED_0603
D3: 5V; LED_0603
D4: 3.3V; LED_0603
D5: LED0; LED_0603
D6: LED1; LED_0603
D7: LED2; LED_0603
D8: LED3; LED_0603
D10: SBR_DIODE; TO-277A
D14: BATT_IN; LED_0603
D15: MAIN_SW; LED_0603
D16: POWER_OUT; LED_0603
D17: FUN_OUT; LED_0603
D18: RELAY_ON; LED_0603
D19: +8V5P; LED_0603
D20: +3V3P; LED_0603
D26: TX; LED_0603
D27: RX; LED_0603
D28: SERIAL; LED_0603
DCDC1: MGFS402412
IC2: MAIN_SHUTDOWN; SOIJ-4_5.3x5.3mm_Pitch1.27mm
IC3: RELAY_STATE; SOIJ-4_5.3x5.3mm_Pitch1.27mm
IC4: ADC_RST; SOIJ-4_5.3x5.3mm_Pitch1.27mm
J1: SERIAL; USB_Micro-B_Molex_47346-0001
JP1: Relay_JP; Pin_Header_Straight_1x02
JP2: SWD_3.3V; GS2
JP3: CAN_JP; Pin_Header_Straight_1x02
L1, L2: 22uH; Inductor_Taiyo-Yuden_NR-50xx_HandSoldering
P1: SWD; ZH_6T
P2, P3: CAN; XA_4T
P4, P5: EMERGENCY_SIGNAL; XA_4T
P6, P7: 12V_OUT; XA_2T
P8: MAIN_~RST; XA_3T
P9: MAIN_SW; XA_2T
P10, P11: EMERGENCY; XA_2T
P12: FRAME_GRAND; SolderWirePad_single_3mmDrill
P13, P16: BATT_IN; XT90PB
P15: OUT_B; XT60_F
P17: OUT_A; XT60_M
Q1, Q4, Q7: FET_N; SOT-23
Q2, Q3: NPN; SOT-23W
R1, R4, R5, R10, R13, R14, R15, R16, R19, R21, R25, R51, R58: 330; R_0603
R2: 1.2k; R_0603
R3, R39, R42: 510; R_0603
R6, R24, R29: 120; R_0603
R7, R8, R17, R18, R22, R23, R26, R27, R32, R40, R43, R49, R54, R59: 10k; R_0603
R11, R37, R38: 2.2k; R_0603
R12: R_JP; R_0603
R20, R28, R48: 10; R_0603
R30, R33, R34, R35, R36, R44, R50: 4.7k; R_0603
R31: 50k; R_0603
R41: 5k; R_0603
R45: 1M; R_0805
R46: 100k; R_0805
R47: 100-1k; R_0603
R52: 10k; R_0805
R53: 1k; R_0805
R55, R56, R57, R60: 2m; WSHP2818
RL1, RL2: 7-1393302-7
SP1: SPEAKER; UGCT7525AN4
SW1: RST; SW_SPST_CK_RS282G05A3
SW2: SW0; SW_SPST_CK_RS282G05A3
SW3: SW1; SW_SPST_CK_RS282G05A3
U1: MAX3051; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: STM32F405RG; LQFP-64_10x10mm_P0.5mm
U3: FULL COLOR; OSTBABS4C2B
U4: AQM0802_BL; AQM0802_BackLight
U5: AP3211; TSOT-6-MK06A
U6: SI8900; SOIC-16_7.5x10.3mm_Pitch1.27mm
U7: AZ1086H
U8: ACS70331; ALLEGRO_ACS70331EESATR-005U3
U9: LOGO; Mega_Fusigibana_15x9_silk
U10: BD9G101G; TSOT-6-MK06A
U11: OUTA_CHECK; SOIC-4_4.55x2.6mm_P1.27mm
U12: LOGO; Libra_15x15_silk
U13: LOGO; RP_KIT_Logo_mask_15.0x15.0
U14: OUTB_CHECK; SOIC-4_4.55x2.6mm_P1.27mm
U15: BD33FA1; SOT89-3_Housing
U16: LOGO; Robocon2020_30.0x12.5_silk
U17: LOGO; Power_logo_Silk_5x5
U18: LOGO; Mini_Monster
U19: MCP2221A; SOIC-14_3.9x8.7mm_Pitch1.27mm
U20, U21: OSRB38C9AA
U22: HSIN_946; relay_HSINDA_Y14H
U23: LOGO; Battery_Killer_logo
U25: LOGO; MonsterBall_10x10_silk
X1: 8MHz; Crystal_SMD_5032_2Pads

Connections:
3V3: AMP1.5 (VCC), AMP2.5 (VCC), C22.2, C33.1, C34.1, C43.2, R30.1, R39.2, U6.1 (VDDA), U6.2 (VREF), U15.1 (Vo)
+3.3V: C4.1, C8.2, C9.2, C10.2, C12.2, C15.2, C18.2, C19.1, C20.1, C26.1, C27.1, C28.1, C41.1, C49.1, D9.2 (K), D26.1 (A), D27.1 (A), D28.1 (A), JP2.2, R4.2, R22.1, R23.1, R26.2, R27.2, R54.2, R59.1, SP1.1, U1.3 (VCC), U2.1 (VBAT), U2.13 (VDDA), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U4.5 (VDD), U4.9 (XRSETB), U4.10 (Anode), U6.10 (VDDB), U6.16 (VDDB), U7.2 (V_OUT), U8.12 (VCC), U11.4, U14.4, U19.1 (Vdd), U19.11 (Vusb)
+5V: C24.1, C29.1, C47.1, C48.1, D13.2 (K), D25.2 (K), D29.2 (K), R3.2, U7.3 (V_IN), U20.3 (Vcc), U21.3 (Vcc), U22.5 (A2)
+8V: C30.2, C37.2, C46.1, IC2.4, L2.2, P10.1, R38.2, R41.1, U15.3 (Vcc)
+12V: C2.1, C6.1, C7.1, C14.1, C16.1, C17.1, D12.1 (A), P2.2, P3.2, P4.2, P5.2, P6.2, P7.2, R2.2, R17.2, U8.3 (IP-), U8.4 (IP-)
+BATT: D10.1 (RIGHT), D10.2 (LEFT), P13.2, P16.2, R33.2, R45.2, RL1.7, RL2.7
/24V: C32.1, D21.1 (A), DCDC1.6 (+Vin), P9.2, R34.2
/ADC12_IN4: U2.20 (ADC12_IN4/PA4)
/ADC12_IN5: U2.21 (ADC12_IN5/TIM2_CH1_ETR/TIM8_CH1N/PA5)
/ADC12_IN6: U2.22 (ADC12_IN6/TIM3_CH1/TIM13_CH1/PA6)
/ADC12_IN7: U2.23 (ADC12_IN7/TIM1_CH1N/TIM8_CH1N/TIM14_CH1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)
/ADC12_IN8: C44.1, R52.1, R53.2, U2.26 (ADC12_IN8/TIM1_CH2N/TIM8_CH2N/TIM3_CH3/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)
/ADC12_IN9: C42.1, R43.1, R47.1, U2.27 (ADC12_IN9/TIM1_CH3N/TIM8_CH3N/TIM3_CH4/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)
/CAN1_RX: U1.4 (RXD), U2.61 (TIM4_CH3/TIM10_CH1/CAN1_RX/PB8)
/CAN1_TX: U1.1 (TXD), U2.62 (TIM4_CH4/TIM11_CH1/CAN1_TX/PB9)
/CAN_H: P2.3, P3.3, R6.1, U1.7 (CANH)
/CAN_L: JP3.2, P2.4, P3.4, U1.6 (CANL)
/Coil: D22.2 (K), D23.2 (K), IC3.1, R37.2, RL1.2, RL2.2, U22.4 (NO)
/CoilReadPin_PA15: Q4.3 (D), R54.1, U2.50 (TIM2_CH1_ETR/PA15)
/D+: J1.3 (D+), U19.13 (D+)
/D-: J1.2 (D-), U19.12 (D-)
/FB: R31.1, R32.2, U5.3 (FB)
/Fource_shutdown: P4.3, P5.3, R15.2
/I2C2_SCL: R26.1, U2.29 (USART3_TX/TIM2_CH3/PB10), U4.8 (SCL)
/I2C2_SDA: R27.1, U2.30 (USART3_RX/TIM2_CH4/PB11), U4.7 (SDA)
/MAIN_~RST: P8.3, U2.57 (CAN2_RX/TIM3_CH2/PB5)
/OSC_IN: C1.1, U2.5 (OSC_IN), X1.1
/OSC_OUT: C5.1, U2.6 (OSC_OUT), X1.2
/OUTA_Current: AMP1.4 (Out), U6.3 (AIN0)
/OUTB_Current: AMP2.4 (Out), U6.4 (AIN1)
/PA0: R49.2, U2.14 (UART4_TX/TIM2_CH1_ETR/ADC12_IN0/TIM5_CH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), U14.3
/PA1: R40.2, U2.15 (UART4_RX/ADC12_IN1/TIM5_CH2/TIM2_CH2/PA1), U11.3
/PB12: U2.33 (CAN2_RX/PB12)
/PB13: U2.34 (TIM1_CH1N/CAN2_TX/PB13)
/PB14: U2.35 (TIM1_CH2N/TIM8_CH2N/TIM12_CH1/PB14)
/PB15: IC4.1, U2.36 (TIM1_CH3N/TIM8_CH3N/TIM12_CH2/PB15)
/PC0: U2.8 (PC0/ADC12_IN10), U20.1 (OUTPUT), U21.1 (OUTPUT)
/PC1: U2.9 (PC1/ADC12_IN11)
/PC2: R18.2, R48.1, U2.10 (PC2/ADC12_IN12)
/PC3: U2.11 (PC3/ADC12_IN13)
/PC4: R23.2, SW3.2, U2.24 (PC4/ADC12_IN14)
/PC5: R22.2, SW2.2, U2.25 (PC5/ADC12_IN15)
/PC6: R10.1, U2.37 (PC6/TIM8_CH1/USART6_TX/TIM3_CH1)
/PC7: R13.1, U2.38 (PC7/TIM8_CH2/USART6_RX/TIM3_CH2)
/PC8: R14.1, U2.39 (PC8/TIM8_CH3/TIM3_CH3)
/PC9: R16.1, U2.40 (PC9/TIM8_CH4/TIM3_CH4)
/PC13: R28.2, U2.2 (PC13)
/PC15: U2.4 (PC15/OSC32_OUT)
/Relay_Out: D22.1 (A), D23.1 (A), JP1.2, Q1.3 (D), RL1.1, RL2.1
/Relay_state: IC3.4, P4.4, P5.4, Q4.1 (G), R17.1
/SWCLK: P1.3, U2.49 (SWCLK/PA14)
/SWDIO: P1.4, U2.46 (SWDIO/PA13)
/TIM1_CH1: R20.2, U2.41 (TIM1_CH1/PA8)
/TIM1_CH2: R21.1, U2.42 (USART1_TX/TIM1_CH2/PA9)
/TIM1_CH3: R5.1, U2.43 (USART1_RX/TIM1_CH3/PA10)
/TIM1_CH4: R1.1, U2.44 (CAN1_RX/TIM1_CH4/PA11)
/To_CurrentA: AMP1.8 (Vp), R55.1, R56.1, RL1.14 (12)
/To_CurrentB: AMP2.8 (Vp), R57.1, R60.1, RL2.14 (12)
/USART1_RX: U2.59 (USART1_RX/TIM4_CH2/PB7), U19.6 (UTx)
/USART1_TX: U2.58 (TIM4_CH1/CAN2_TX/USART1_TX/PB6), U19.5 (URx)
/USART2_RX: U2.17 (USART2_RX/TIM5_CH4/TIM9_CH2/ADC12_IN3/T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), U6.12 (TX)
/USART2_TX: U2.16 (USART2_TX/TIM5_CH3/TIM9_CH1/ADC12_IN2/T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), U6.13 (RX)
/Voltage: C38.1, R45.1, R46.2, U6.5 (AIN2)
/~RST: C3.1, P1.5, SW1.1, U2.7 (NRST)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.2, C12.1, C13.2, C14.2, C15.1, C16.2, C17.2, C18.1, C19.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C35.2, C41.2, C42.2, C44.2, C47.2, C48.2, C49.2, D2.2 (K), D3.2 (K), D4.2 (K), D5.2 (K), D6.2 (K), D7.2 (K), D8.2 (K), D11.1 (A), DCDC1.1 (-Vout), IC2.2, IC3.3, J1.5 (GND), P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.1, P8.1, Q2.2 (E), Q3.2 (E), Q4.2 (S), Q7.2 (S), R8.2, R12.2, R18.1, R25.1, R32.1, R40.1, R43.2, R49.1, R53.1, SW1.2, SW2.1, SW3.1, U1.2 (GND), U2.12 (VSSA), U2.18 (VSS), U2.63 (VSS), U3.4 (red_K), U3.5 (green_K), U3.6 (blue_K), U4.6 (VSS), U5.2 (GND), U6.9 (GNDB), U7.1 (GND), U8.5 (GND)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
GNDPWR: AMP1.2 (SEL1), AMP1.3 (SEL2), AMP1.6 (GND), AMP1.7 (VCC-), AMP2.2 (SEL1), AMP2.3 (SEL2), AMP2.6 (GND), AMP2.7 (VCC-), C22.1, C31.2, C32.2, C33.2, C34.2, C37.1, C38.2, C43.1, C46.2, D14.2 (K), D15.2 (K), D16.2 (K), D17.2 (K), D18.2 (K), D19.2 (K), D20.2 (K), D24.1 (A), DCDC1.4 (RC), DCDC1.5 (-Vin), IC4.3, JP1.1, P12.1, P13.1, P15.1, P16.1, P17.1, Q1.2 (S), R7.1, R11.1, R42.1, R44.1, R46.1, R50.1, U6.8 (GNDA), U10.2 (GND), U15.2 (FIN)
unnamed: C11.1, U2.31 (VCAP_1)
unnamed: C13.1, U2.47 (VCAP_2)
unnamed: C20.2, U4.2 (VOUT)
unnamed: C21.1, U4.4 (CAP1P)
unnamed: C21.2, U4.3 (CAP1N)
unnamed: C23.1, D11.2 (K), L1.1, U5.6 (SW)
unnamed: C23.2, U5.1 (BS)
unnamed: C25.1, D12.2 (K), U5.4 (EN), U5.5 (IN)
unnamed: C30.1, R41.2, R42.2, U10.3 (FB)
unnamed: C31.1, D21.2 (K), U10.4 (EN), U10.5 (VCC)
unnamed: C35.1, DCDC1.3 (+Vout), R52.2, U8.1 (IP+), U8.2 (IP+)
unnamed: C36.1, U10.1 (BST)
unnamed: C36.2, D24.2 (K), L2.1, U10.6 (Lx)
unnamed: D1.1 (A), P1.2
unnamed: D1.2 (K), JP2.1
unnamed: D2.1 (A), R2.1
unnamed: D3.1 (A), R3.1
unnamed: D4.1 (A), R4.1
unnamed: D5.1 (A), R10.2
unnamed: D6.1 (A), R13.2
unnamed: D7.1 (A), R14.2
unnamed: D8.1 (A), R16.2
unnamed: D9.1 (A), R24.2, SP1.2
unnamed: D10.3 (Kathode), P9.1
unnamed: D13.1 (A), L1.2, R31.2
unnamed: D14.1 (A), R33.1
unnamed: D15.1 (A), R34.1
unnamed: D16.1 (A), R35.1
unnamed: D17.1 (A), R36.1
unnamed: D18.1 (A), R37.1
unnamed: D19.1 (A), R38.1
unnamed: D20.1 (A), R39.1
unnamed: D25.1 (A), Q7.3 (D), U22.2 (A1)
unnamed: D26.2 (K), R19.1
unnamed: D27.2 (K), R51.1
unnamed: D28.2 (K), R58.1
unnamed: D29.1 (A), J1.1 (VBUS)
unnamed: IC2.1, R15.1
unnamed: IC2.3, Q1.1 (G), R7.2
unnamed: IC3.2, R11.2
unnamed: IC4.2, R25.2
unnamed: IC4.4, R30.2, U6.7 (~RST~)
unnamed: JP3.1, R6.2
unnamed: P10.2, P11.1
unnamed: P11.2, U22.1 (COM)
unnamed: Q2.1 (B), R20.1
unnamed: Q2.3 (C), R24.1
unnamed: Q3.1 (B), R28.1
unnamed: Q3.3 (C), R29.1
unnamed: Q7.1 (G), R48.2
unnamed: R1.2, U3.1 (blue_A)
unnamed: R5.2, U3.2 (green_A)
unnamed: R8.1, U2.60 (BOOT0)
unnamed: R12.1, U1.8 (RS)
unnamed: R19.2, U19.2 (GP0)
unnamed: R21.2, U3.3 (red_A)
unnamed: R29.2, U4.11 (Cathode)
unnamed: R44.2, U11.2
unnamed: R47.2, U8.10 (VIOUT)
unnamed: R50.2, U14.2
unnamed: R51.2, U19.3 (GP1)
unnamed: R58.2, U19.7 (GP2)
unnamed: R59.2, U19.4 (nRST)
OUT_A: AMP1.1 (Vm), P17.2, R35.2, R55.2, R56.2, U11.1
OUT_B: AMP2.1 (Vm), P15.2, R36.2, R57.2, R60.2, U14.1

Notes on the sheet:
USER LEDs, Switches
Emergncy Signal From Main Controll Circuit's I/O
CAN
Functions
Microcontroller Circuit
LOGOs
Power Suppry Connectors
LEDs
Relay, Current measure and Check Power Out
Voltage measure
Emergency, Main Switch
Isolation ADC
Power Drop Out Regulators
Control Voltage Supply

Board: 2 copper layers, 100.0 x 77.0 mm, 198 parts (112 on the bottom side), 121 nets.
