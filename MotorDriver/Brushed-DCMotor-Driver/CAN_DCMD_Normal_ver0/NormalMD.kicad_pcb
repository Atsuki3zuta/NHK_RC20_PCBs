# Repository Atsuki3zuta/NHK_RC20_PCBs (continued)

## KiCad design MotorDriver/Brushed-DCMotor-Driver/CAN_Current_Control_MD_ver0/CAN_Current_Control_MD.kicad_pcb

Parts:
C1, C8, C11, C12, C19, C20, C21, C22, C23, C24, C28, C31, C32, C33, C34, C35, C36, C38, C39, C40, C41, C42, C55, C56, C57: 0.1u; 1608_WP
C2, C5, C25, C43, C44, C45, C46, C47, C52, C53: 4.7u; C_0805_2012Metric
C3, C4: 22p; 1608_WP
C6, C7, C9, C10, C37, C54: 0.1u; C_0603_1608Metric
C13, C26, C27: 1u; 1608_WP
C14, C16: 2.2u; 1608_WP
C15: 4.7u; 1608_WP
C17: 10u; 1608_WP
C18: 22u; 1608_WP
C29, C49: 10u; C_0805_2012Metric
C30, C48, C50: 100u; CP_Radial_D5.0mm_P2.50mm
C51: 1500u; C_Radial_D13mm_H25.0mm_P5.00mm
D1: 12V; 1608_WP
D2: 3V3; 1608_WP
D3, D11, D14, D15, D16, D17, D18, D19, D20, D21, D22, D24, D26: DIODE; D_SOD-123
D4: BATT; LED_0603_1608Metric
D5: MAIN_BATT; LED_0603_1608Metric
D6: 12VP; LED_0603_1608Metric
D7: 5VP; LED_0603_1608Metric
D8: 3V3P; LED_0603_1608Metric
D9: EMG0; 1608_WP
D10: BUS0; 1608_WP
D12: EMG1; 1608_WP
D13: BUS1; 1608_WP
D23: DIODE; D_SMA
D25: VALVE0; LED_0603_1608Metric
D27: VALVE1; LED_0603_1608Metric
F1: Polyfuse; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
J1: SWD; ZH_6P
J2, J3: CAN; XA_4L
J4: ENC0; XA_4L
J5: ENC1; XA_4L
J6: I/O_0; XA_3L
J7: I/O_1; XA_3L
J8: BATT_IN; XT60_F
J9: BATT_IN; XT60_M
J10: FAN; XA_2P
J11: OUT_0; XT60_F
J12: OUT_1; XT60_F
J13: VALVE; XA_4L
J14: SERIAL; PinSocket_1x04_P2.54mm_Vertical
JP1: SWD_JP; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP2: CAN_JP; PinHeader_1x02_P2.54mm_Vertical
JP3: I/O_Vdd; PinHeader_1x03_P2.54mm_Vertical
L1, L2: 22uH; Inductor_Taiyo-Yuden_NR-50xx_HandSoldering
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: MOSFET_N; D2-PAK_compact
Q9, Q10: NPN; SOT-23
R1: 2.2k; 1608_WP
R2, R6: 510; 1608_WP
R3, R4: 4.7k; R_0603_1608Metric
R5: 2.2k; R_0603_1608Metric
R7, R63, R64: 330; 1608_WP
R8, R9, R10, R31: 10k; R_0603_1608Metric
R11, R12, R13, R14: 240; R_0603_1608Metric
R15: 120; R_0603_1608Metric
R16, R17, R18, R19, R30, R32, R33, R34, R35, R36, R38, R39, R41, R43, R45, R47: 10k; 1608_WP
R20, R21, R22, R23: 4.7k; 1608_WP
R24, R25, R26, R27, R37: 1k; 1608_WP
R28: 3.9k; R_0603_1608Metric
R29: 680; R_0603_1608Metric
R40, R42, R44, R46: 10; 1608_WP
R48: 7.5k; R_0603_1608Metric
R49: 510; R_0603_1608Metric
R50, R51, R52, R53, R54, R55, R56, R57: FILTER; R_0603_1608Metric
R58, R59, R60, R61: 2m; R_2010_5025Metric
R62: 47; R_2812
SW1: SW0; SW_SPST_PTS810
SW2: SW1; SW_SPST_PTS810
SW3: RST; SW_SPST_CK_RS282G05A3
TH1, TH2, TH3, TH4, TH5: Thermistor; 1608_WP
U1: BD33FA1; SOT-89-3
U2: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm
U3: STM32F405RG; LQFP-64_10x10mm_P0.5mm
U4: ADRESS; rotary_0F
U5: AZ1086H; SOT-223-3_TabPin2
U6, U12: BD9G101G; TSOP-6_1.65x3.05mm_P0.95mm
U7: AQM0802; AQM0802_original
U8, U9, U10, U11: NCP5104; SOIC-8_3.9x4.9mm_P1.27mm
U13, U14: INA181A1; SOT-23-6
U15: LOGO; Mini_Monster
Y1: 8MHz; Crystal_SMD_5032_2Pads

Connections:
+3.3VP: C6.1, C7.1, C8.1, C11.1, C12.1, C13.1, C15.1, C26.2, C28.2, C55.1, C56.1, D3.1 (K), D14.1 (K), JP3.1, R7.2, R11.1, R12.1, R13.1, R14.1, R30.2, R31.1, R32.2, TH1.1, TH2.1, TH3.1, TH4.1, TH5.1, U2.1 (VCC1), U3.1 (VBAT), U3.13 (VDDA), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U7.5 (VDD), U7.9 (/RST), U13.6 (V+), U14.6 (V+)
+3V3: C1.1, C5.1, R2.2, U1.1 (Vo), U2.8 (VCC2)
+5VP: C17.1, C20.2, C21.2, C57.2, F1.1, J4.2, J5.2, J14.1, JP3.3, R6.2, R8.1, R10.1, R24.2, R25.2, R26.2, R27.2, U5.3 (V_IN)
+12P: C25.1, C50.1, D6.2 (A), D22.1 (K), J13.2, J13.4, R40.2, R42.2, R44.2, R46.2, U6.4 (EN), U6.5 (VCC)
+12V: C2.1, D11.1 (K), R1.2, U1.3 (Vcc)
+BATT: C51.1, C52.1, C53.1, D23.2, J8.2, J9.2, Q1.D, Q3.D, Q5.D, Q7.D, R3.2
/ADRESS_1: U3.20 (ADC12_IN4/PA4), U4.3 (1)
/ADRESS_2: U3.27 (ADC12_IN9/TIM1_CH3N/TIM8_CH3N/TIM3_CH4/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), U4.1 (2)
/ADRESS_4: U3.23 (ADC12_IN7/TIM1_CH1N/TIM8_CH1N/TIM14_CH1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), U4.4
/ADRESS_8: U3.22 (ADC12_IN6/TIM3_CH1/TIM13_CH1/PA6), U4.6 (8)
/BATTERY_VOLTAGE: C34.1, R36.2, R37.1, U3.15 (UART4_RX/ADC12_IN1/TIM5_CH2/TIM2_CH2/PA1)
/CAN1_RX: U2.2 (RXD), U3.61 (TIM4_CH3/TIM10_CH1/CAN1_RX/PB8)
/CAN1_TX: U2.3 (TXD), U3.62 (TIM4_CH4/TIM11_CH1/CAN1_TX/PB9)
/CAN_H: J2.3, J3.3, JP2.1, U2.7 (CANH)
/CAN_L: J2.4, J3.4, R15.1, U2.6 (CANL)
/Current0_Analog: U3.10 (PC2/ADC12_IN12), U13.1
/Current1_Analog: U3.11 (PC3/ADC12_IN13), U14.1
/EN0: R41.1, R43.1, U3.37 (PC6/TIM8_CH1/USART6_TX/TIM3_CH1), U8.3, U9.3
/EN1: R45.1, R47.1, U3.34 (TIM1_CH1N/CAN2_TX/PB13), U10.3, U11.3
/FB_5V: C29.1, C30.1, D16.2 (A), L1.2, R28.1
/FB_12V: C49.1, D22.2 (A), L2.2, R48.1
/I2C2_SCL: R30.1, U3.29 (USART3_TX/TIM2_CH3/PB10), U7.8 (SCL)
/I2C2_SDA: R32.1, U3.30 (USART3_RX/TIM2_CH4/PB11), U7.7 (SDA)
/IO_0: J6.3, U3.2 (PC13)
/IO_1: J7.3, U3.3 (PC14/OSC32_IN)
/LED0: D9.1 (K), U3.52 (PC11/UART4_RX/USART3_RX)
/LED1: D10.1 (K), U3.53 (PC12/UART5_TX)
/LED2: D12.1 (K), U3.54 (PD2/UART5_RX)
/LED3: D13.1 (K), U3.55 (TIM2_CH2/PB3)
/MD0L_Temp: C32.1, R34.1, TH2.2, U3.9 (PC1/ADC12_IN11)
/MD0R_Temp: C35.1, R38.1, TH4.2, U3.8 (PC0/ADC12_IN10)
/MD1L_Temp: C33.1, R35.1, TH3.2, U3.26 (ADC12_IN8/TIM1_CH2N/TIM8_CH2N/TIM3_CH3/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)
/MD1R_Temp: C36.1, R39.1, TH5.2, U3.25 (PC5/ADC12_IN15)
/OSC_IN: C3.1, U3.5 (OSC_IN), Y1.1
/OSC_OUT: C4.1, U3.6 (OSC_OUT), Y1.2
/PWM0L: U3.39 (PC8/TIM8_CH3/TIM3_CH3), U8.2
/PWM0R: U3.38 (PC7/TIM8_CH2/USART6_RX/TIM3_CH2), U9.2
/PWM1L: U3.36 (TIM1_CH3N/TIM8_CH3N/TIM12_CH2/PB15), U10.2
/PWM1R: U3.35 (TIM1_CH2N/TIM8_CH2N/TIM12_CH1/PB14), U11.2
/SW0: R8.2, SW1.2, U3.40 (PC9/TIM8_CH4/TIM3_CH4)
/SW1: R10.2, SW2.2, U3.41 (TIM1_CH1/PA8)
/SWCLK: J1.3, U3.49 (SWCLK/PA14)
/SWDIO: J1.4, U3.46 (SWDIO/PA13)
/Substrate_Temp: C31.1, R33.1, TH1.2, U3.21 (ADC12_IN5/TIM2_CH1_ETR/TIM8_CH1N/PA5)
/TIM3_CH1: R17.2, R21.2, U3.56 (TIM3_CH1/PB4)
/TIM3_CH2: R19.2, R23.2, U3.57 (CAN2_RX/TIM3_CH2/PB5)
/TIM4_CH1: R16.2, R20.2, U3.58 (TIM4_CH1/CAN2_TX/USART1_TX/PB6)
/TIM4_CH2: R18.2, R22.2, U3.59 (USART1_RX/TIM4_CH2/PB7)
/USART1_RX: J14.3, U3.43 (USART1_RX/TIM1_CH3/PA10)
/USART1_TX: J14.4, U3.42 (USART1_TX/TIM1_CH2/PA9)
/VALVE0: Q9.1 (B), R63.1
/VALVE1: Q10.1 (B), R64.1
/~RST: C54.1, J1.5, SW3.2, U3.7 (~RST)
Batt: C47.1, C48.1, D23.1, R4.2, R36.1, R62.2, U12.4 (EN), U12.5 (VCC)
GND: C1.2, C2.2, C5.2, C9.1, C10.1, D1.1 (K), D2.1 (K), J2.1, J3.1, U1.2 (FIN), U2.5 (GND2)
GNDPWR: C3.2, C4.2, C6.2, C7.2, C8.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.1, C23.1, C24.1, C25.2, C28.1, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.1, D4.1 (K), D5.1 (K), D7.1 (K), D8.1 (K), D15.2 (A), D21.2 (A), D24.2 (A), D25.1 (K), D26.2 (A), D27.1 (K), J1.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J14.2, Q9.2 (E), Q10.2 (E), R5.1, R9.2, R16.1, R17.1, R18.1, R19.1, R29.2, R33.2, R34.2, R35.2, R37.2, R38.2, R39.2, R41.2, R43.2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
MD0_OUT: Q2.S, Q4.S, R58.2, R60.2, U13.3 (+)
MD1_OUT: Q6.S, Q8.S, R59.2, R61.2, U14.3 (+)
unnamed: C9.2, C10.2, D11.2 (A), J2.2, J3.2
unnamed: C14.1, U3.31 (VCAP_1)
unnamed: C16.1, U3.47 (VCAP_2)
unnamed: C18.1, D14.2 (A), U5.2 (V_OUT)
unnamed: C19.1, R28.2, R29.1, U6.3 (FB)
unnamed: C22.1, D15.1 (K), L1.1, U6.6 (Lx)
unnamed: C22.2, U6.1 (BST)
unnamed: C23.2, C24.2, J6.2, J7.2, JP3.2
unnamed: C26.1, U7.2 (VOUT)
unnamed: C27.1, U7.3 (CAP1N)
unnamed: C27.2, U7.4 (CAP1P)
unnamed: C37.1, R48.2, R49.1, U12.3 (FB)
unnamed: C38.1, D17.2 (A), R40.1, U8.1
unnamed: C39.1, D18.2 (A), R42.1, U9.1
unnamed: C40.1, D19.2 (A), R44.1, U10.1
unnamed: C41.1, D20.2 (A), R46.1, U11.1
unnamed: C42.1, D21.1 (K), L2.1, U12.6 (Lx)
unnamed: C42.2, U12.1 (BST)
unnamed: C43.1, D17.1 (K), U8.8
unnamed: C44.1, D18.1 (K), U9.8
unnamed: C45.1, D19.1 (K), U10.8
unnamed: C46.1, D20.1 (K), U11.8
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), JP1.2
unnamed: D4.2 (A), R3.1
unnamed: D5.2 (A), R4.1
unnamed: D6.1 (K), R5.2
unnamed: D7.2 (A), R6.1
unnamed: D8.2 (A), R7.1
unnamed: D9.2 (A), R11.2
unnamed: D10.2 (A), R12.2
unnamed: D12.2 (A), R13.2
unnamed: D13.2 (A), R14.2
unnamed: D16.1 (K), F1.2
unnamed: D24.1 (K), J13.1, Q9.3 (C)
unnamed: D25.2 (A), R63.2
unnamed: D26.1 (K), J13.3, Q10.3 (C)
unnamed: D27.2 (A), R64.2
unnamed: J1.2, JP1.1
unnamed: J4.3, R22.1, R26.1
unnamed: J4.4, R20.1, R24.1
unnamed: J5.3, R23.1, R27.1
unnamed: J5.4, R21.1, R25.1
unnamed: J10.2, R62.1
unnamed: JP2.2, R15.2
unnamed: Q1.G, R50.1
unnamed: Q2.G, R51.1
unnamed: Q3.G, R52.1
unnamed: Q4.G, R53.1
unnamed: Q5.G, R54.1
unnamed: Q6.G, R55.1
unnamed: Q7.G, R56.1
unnamed: Q8.G, R57.1
unnamed: R9.1, U3.60 (BOOT0)
unnamed: R31.2, U3.28 (BOOT1/PB2)
unnamed: R50.2, U8.7
unnamed: R51.2, U8.5
unnamed: R52.2, U9.7
unnamed: R53.2, U9.5
unnamed: R54.2, U10.7
unnamed: R55.2, U10.5
unnamed: R56.2, U11.7
unnamed: R57.2, U11.5
OUT0_L: C43.2, J11.1, Q1.S, Q2.D, U8.6
OUT0_R: C44.2, J11.2, Q3.S, Q4.D, U9.6
OUT1_L: C45.2, J12.1, Q5.S, Q6.D, U10.6
OUT1_R: C46.2, J12.2, Q7.S, Q8.D, U11.6

Notes on the sheet:
PolyFuse : http://akizukidenshi.com/catalog/g/gP-10074/
FILTER : 3Ohm

Board: 2 copper layers, 75.0 x 81.0 mm, 202 parts (92 on the bottom side), 126 nets.
