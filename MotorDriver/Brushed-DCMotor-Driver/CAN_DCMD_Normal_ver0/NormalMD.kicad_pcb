# Repository Atsuki3zuta/NHK_RC20_PCBs (continued)

## KiCad design other/F407_io_ver2(青基板)/stm32f4_board_test.kicad_pcb

Parts:
C1, C4, C5, C6, C9, C10, C13, C15, C16, C17, C18, C19, C20, C21, C22, C24, C25, C27, C28: 0.1u; C_0603_1608Metric
C2, C3: 2.2u; C_0603_1608Metric
C7, C8: 22p; C_0603_1608Metric
C11, C12: 22u; C_0603_1608Metric
C14, C23, C26: 1u; C_0603_1608Metric
D1, D2, D6, D15: DIODE; D_SOD-123
D3: 12V; LED_0603_1608Metric
D4: 5V; LED_0603_1608Metric
D5: 3.3V; LED_0603_1608Metric_Castellated
D7, D8, D9, D10, D11, D12, D13, D14: LED; LED_0603_1608Metric
JP1: 3.3VJP; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP2: CAN_JP; PinHeader_1x02_P2.54mm_Vertical
JP3: I/O_Vdd_JP; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
JP4: VALVE_JP; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
L1: 22uH; L_Taiyo-Yuden_NR-50xx_HandSoldering
P1: ENC3; XA_4P
P2: ENC0; XA_4P
P3: ENC1; XA_4P
P4: ENC2; XA_4P
P5: USART1; XA_4P
P6: SWD; PinHeader_1x05_P2.54mm_Vertical
P7, P8: CAN; XA_4P
P9: VALVE; PinHeader_1x08_P2.54mm_Vertical
P10: ADC; PinHeader_1x04_P2.54mm_Vertical
P11: PWM; PinHeader_1x04_P2.54mm_Vertical
P12: I/O; PinHeader_1x04_P2.54mm_Vertical
P13: ADC_Vdd; PinHeader_2x04_P2.54mm_Vertical
P14: PWM_Vdd; PinHeader_2x04_P2.54mm_Vertical
P15: I/O_Vdd; PinHeader_2x04_P2.54mm_Vertical
P16: VALVE_Vdd; PinHeader_2x08_P2.54mm_Vertical
P17: USART0; XA_4P
R1, R2, R6, R7, R10, R11, R14, R15: 1k; R_0603_1608Metric
R3, R4, R8, R9, R12, R13, R16, R17: 100; R_0603_1608Metric
R5, R20, R21, R29, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46: 330; R_0603_1608Metric
R18, R19, R28, R30, R31, R32, R33, R51, R52: 10k; R_0603_1608Metric
R22: 120; R_0603_1608Metric
R23, R24, R25: 240; R_0603_1608Metric
R26: 1.2k; R_0603_1608Metric
R27: 510; R_0603_1608Metric
R50: 50k; R_0603_1608Metric
SW1: ADDR; KHS4
SW2: SW0; SMD_Button
SW3: SW1; SMD_Button
SW6: RESET; SMD_Button
U1: STM32F407VG; LQFP-100_14x14mm_P0.5mm
U2: AP3211; TSOP-6_1.65x3.05mm_P0.95mm
U3: OSTBABS4C2B; LED_RGB_5050-6
U4: AZ1086H; SOT-223-3_TabPin2
U5: MAX3051; SOIC-8_3.9x4.9mm_P1.27mm
U6: TBD62083A; SOIC-18W_7.5x11.6mm_P1.27mm
U7: ADRES; OSL10321-Lx
U8: LOGO; kitLogo_5.1x5.1
U9: LOGO; Mini_Monster
Y1: Crystal; Crystal_SMD_5032_2Pads

Connections:
+3V3: C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C21.1, C22.2, C23.2, D1.1 (K), JP1.2, JP3.1, P13.1, P13.3, P13.5, P13.7, P14.1, P14.3, P14.5, P14.7, R1.1, R2.1, R6.1, R7.1, R10.1, R11.1, R14.1, R15.1, R29.1, R52.1, SW1.1, SW1.2, SW1.3, SW1.4, SW2.2, SW3.2, U1.6 (VBAT), U1.11 (VDD), U1.19 (VDD), U1.21 (VREF+), U1.22 (VDDA), U1.28 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U5.3 (VCC)
+5V: C1.1, C4.1, C5.1, C6.1, C9.1, C11.1, C27.1, C28.1, D15.1 (K), JP3.3, JP4.3, P1.2, P2.2, P3.2, P4.2, P5.2, P17.2, R27.1, U4.3 (V_IN)
+12V: C26.1, D6.1 (K), JP4.1, R26.1, U2.4 (EN), U2.5 (IN)
/AD1_IN10: P10.4, U1.15 (PC0/OTG_HS_ULPI_STP/EVENTOUT)
/AD1_IN11: P10.3, U1.16 (PC1/ETH_MDC/_EVENTOUT)
/AD1_IN12: P10.2, U1.17 (PC2/SPI2_MISO/OTG_HS_ULPI_DIR/ETH_MII_T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)
/AD1_IN13: P10.1, U1.18 (PC3/SPI2_MOSI/I2S2_SD/OTG_HS_ULPI_NXT/E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)
/ADRESS0: R30.1, SW1.5, U1.33 (PC4/ETH_RMII_RX_D0/ETH_MII_RX_D0/EVENTO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)
/ADRESS1: R31.1, SW1.6, U1.34 (PC5/ETH_RMII_RX_D1/ETH_MII_RX_D1/EVENTO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)
/ADRESS2: R32.1, SW1.7, U1.35 (PB0/TIM3_CH3/TIM8_CH2N/OTG_HS_ULPI_D1/E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)
/ADRESS3: R33.1, SW1.8, U1.36 (PB1/TIM3_CH4/TIM8_CH3N/OTG_HS_ULPI_D2/E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)
/CAN1_H: P7.3, P8.3, R22.2, U5.7 (CANH)
/CAN1_L: JP2.2, P7.4, P8.4, U5.6 (CANL)
/CAN1_RX: U1.81 (PD0/FSMC_D2/CAN1_RX/EVENTOUT), U5.4 (RXD)
/CAN1_TX: U1.82 (PD1/FSMC_D3/CAN1_TX/EVENTOUT), U5.1 (TXD)
/FB: R50.1, R51.2, U2.3 (FB)
/LED0: R42.2, U1.55 (PD8/FSMC_D13/USART3_TX/EVENTOUT)
/LED1: R44.2, U1.56 (PD9/FSMC_D14/USART3_RX/EVENTOUT)
/LED2: R45.2, U1.57 (PD10/FSMC_D15/USART3_CK/EVENTOUT)
/LED3: R21.2, U1.58 (PD11/FSMC_CLE/FSMC_A16/USART3_CTS/EVENT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)
/LED4: R20.2, U1.59 (PD12/FSMC_ALE/FSMC_A17/TIM4_CH1/USART3_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)
/LED5: R43.2, U1.60 (PD13/FSMC_A18/TIM4_CH2/EVENTOUT)
/LED6: R5.2, U1.61 (PD14/FSMC_D0/TIM4_CH3/EVENTOUT/_EVENTOUT)
/LED7: R46.1, U1.62 (PD15/FSMC_D1/TIM4_CH4/EVENTOUT)
/OSC_IN: C8.1, U1.12 (PH0/OSC_IN/EVENTOUT), Y1.2
/OSC_OUT: C7.1, U1.13 (PH1/OSC_OUT/EVENTOUT), Y1.1
/PA2: P12.1, U1.25 (PA2/USART2_TX/TIM5_CH3/TIM9_CH1/TIM2_CH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)
/PC13: P12.4, U1.7 (PC13/EVENTOUT)
/PC14: P12.3, U1.8 (PC14/OSC32_IN/EVENTOUT)
/PC15: P12.2, U1.9 (PC15/OSC32_OUT/EVENTOUT)
/PE8: R34.1, U1.39 (PE8/FSMC_D5/TIM1_CH1N/EVENTOUT), U6.1 (IN1)
/PE9: R35.1, U1.40 (PE9/FSMC_D6/TIM1_CH1/EVENTOUT), U6.2 (IN2)
/PE10: R36.1, U1.41 (PE10/FSMC_D7/TIM1_CH2N/EVENTOUT), U6.3 (IN3)
/PE11: R37.1, U1.42 (PE11/FSMC_D8/TIM1_CH2/EVENTOUT), U6.4 (IN4)
/PE12: R38.1, U1.43 (PE12/FSMC_D9/TIM1_CH3N/EVENTOUT), U6.5 (IN5)
/PE13: R39.1, U1.44 (PE13/FSMC_D10/TIM1_CH3/EVENTOUT), U6.6 (IN6)
/PE14: R40.1, U1.45 (PE14/FSMC_D11/TIM1_CH4/EVENTOUT), U6.7 (IN7)
/PE15: R41.1, U1.46 (PE15/FSMC_D12/TIM1_BKIN/EVENTOUT), U6.8 (IN8)
/SW0: R18.1, SW2.1, U1.65 (PC8/TIM8_CH3/SDIO_D0/TIM3_CH3/USART6_CK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)
/SW1: R19.1, SW3.1, U1.66 (PC9/I2S_CKIN/MCO2/TIM8_CH4/SDIO_D1/I2C3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)
/SWCLK: P6.3, U1.76 (PA14/JTCK/SWCLK/EVENTOUT)
/SWDIO: P6.4, U1.72 (PA13/JTMS/SWDIO/EVENTOUT)
/TIM3_CH1: R17.1, U1.31 (PA6/SPI1_MISO/TIM8_BKIN/TIM13_CH1/DCMI_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)
/TIM3_CH2: R16.1, U1.32 (PA7/SPI1_MOSI/TIM8_CH1N/TIM14_CH1/TIM3_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)
/TIM4_CH1: R4.1, U1.92 (PB6/I2C1_SCL/TIM4_CH1/CAN2_TX/DCMI_D5/U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)
/TIM4_CH2: R3.1, U1.93 (PB7/I2C1_SDA/FSMC_NL/DCMI_VSYNC/USART1_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)
/TIM5_CH1: R9.1, U1.23 (PA0/WKUP/USART2_CTS/UART4_TX/ETH_MII_CR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)
/TIM5_CH2: R8.1, U1.24 (PA1/USART2_RTS/UART4_RX/ETH_RMII_REF_CL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)
/TIM8_CH1: R13.1, U1.63 (PC6/I2S2_MCK/TIM8_CH1/SDIO_D6/USART6_TX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)
/TIM8_CH2: R12.1, U1.64 (PC7/I2S3_MCK/TIM8_CH2/SDIO_D7/USART6_RX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)
/TIM9_CH1: P11.2, U1.4 (PE5/TRACED2/FSMC_A21/TIM9_CH1/DCMI_D6/E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)
/TIM9_CH2: P11.1, U1.5 (PE6/TRACED3_/_FSMC_A22/TIM9_CH2/DCMI_D7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)
/TIM10_CH1: P11.4, U1.95 (PB8/TIM4_CH3/SDIO_D4/TIM10_CH1/DCMI_D6/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)
/TIM11_CH1: P11.3, U1.96 (PB9/SPI2_NSS/I2S2_WS/TIM4_CH4/TIM11_CH1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)
/TIM12_CH1: U1.53 (PB14/SPI2_MISO/TIM1_CH2N/TIM12_CH1/OTG_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)
/TIM_CH1: R23.2, U1.67 (PA8/MCO1/USART1_CK/TIM1_CH1/I2C3_SCL/OT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)
/TIM_CH2: R24.2, U1.68 (PA9/USART1_TX/TIM1_CH2/I2C3_SMBA/DCMI_D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)
/TIM_CH3: R25.2, U1.69 (PA10/USART1_RX/TIM1_CH3/OTG_FS_ID/DCMI_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)
/UART4_RX: P5.4, U1.79 (PC11/UART4_RX/SPI3_MISO/SDIO_D3/DCMI_D4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)
/UART4_TX: P5.3, U1.78 (PC10/SPI3_SCK/I2S3_CK/UART4_TX/SDIO_D2/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)
/UART5_RX: U1.83 (PD2/TIM3_ETR/UART5_RX/SDIO_CMD/DCMI_D11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)
/UART5_TX: U1.80 (PC12/UART5_TX/SDIO_CK/DCMI_D9/SPI3_MOSI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)
/USART3_RX: P17.4, U1.48 (PB11/I2C2_SDA/USART3_RX/OTG_HS_ULPI_D4/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)
/USART3_TX: P17.3, U1.47 (PB10/SPI2_SCK/I2S2_CK/I2C2_SCL/USART3_T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)
/VALVE: JP4.2, P16.1, P16.3, P16.5, P16.7, P16.9, P16.11, P16.13, P16.15, U6.10 (COM)
/VALVE0: P9.1, U6.11 (OUT8)
/VALVE1: P9.2, U6.12 (OUT7)
/VALVE2: P9.3, U6.13 (OUT6)
/VALVE3: P9.4, U6.14 (OUT5)
/VALVE4: P9.5, U6.15 (OUT4)
/VALVE5: P9.6, U6.16 (OUT3)
/VALVE6: P9.7, U6.17 (OUT2)
/VALVE7: P9.8, U6.18 (OUT1)
/nRST: C10.1, P6.5, SW6.2, U1.14 (NRST)
CAN1_BUS_VDD: C20.1, C24.1, D6.2 (A), P7.2, P8.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.1, C24.2, C26.2, C27.2, C28.2, D2.2 (A), D3.1 (K), D4.1 (K), D5.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.1, P8.1, P13.2, P13.4, P13.6, P13.8, P14.2, P14.4, P14.6, P14.8, P15.2, P15.4, P15.6, P15.8, P16.2, P16.4, P16.6, P16.8, P16.10, P16.12, P16.14, P16.16, P17.1, R18.2, R19.2, R28.2, R30.2, R31.2, R32.2, R33.2, R51.1, SW6.1, U1.10 (VSS), U1.20 (VSSA), U1.27 (VSS)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
unnamed: C2.1, U1.49 (VCAP_1)
unnamed: C3.1, U1.73 (VCAP_2)
unnamed: C12.1, D1.2 (A), U4.2 (V_OUT)
unnamed: C25.1, D2.1 (K), L1.1, U2.6 (SW)
unnamed: C25.2, U2.1 (BS)
unnamed: D3.2 (A), R26.2
unnamed: D4.2 (A), R27.2
unnamed: D5.2 (A), R29.2
unnamed: D7.2 (A), R34.2
unnamed: D8.2 (A), R35.2
unnamed: D9.2 (A), R36.2
unnamed: D10.2 (A), R37.2
unnamed: D11.2 (A), R38.2
unnamed: D12.2 (A), R39.2
unnamed: D13.2 (A), R40.2
unnamed: D14.2 (A), R41.2
unnamed: D15.2 (A), L1.2, R50.2
unnamed: JP1.1, P6.2
unnamed: JP2.1, R22.1
unnamed: JP3.2, P15.1, P15.3, P15.5, P15.7
unnamed: P1.3, R1.2, R3.2
unnamed: P1.4, R2.2, R4.2
unnamed: P2.3, R6.2, R8.2
unnamed: P2.4, R7.2, R9.2
unnamed: P3.3, R10.2, R12.2
unnamed: P3.4, R11.2, R13.2
unnamed: P4.3, R14.2, R16.2
unnamed: P4.4, R15.2, R17.2
unnamed: R5.1, U7.8
unnamed: R20.1, U7.5
unnamed: R21.1, U7.4
unnamed: R23.1, U3.1 (blue_A)
unnamed: R24.1, U3.2 (green_A)
unnamed: R25.1, U3.3 (red_A)
unnamed: R28.1, U1.94 (BOOT0)
unnamed: R42.1, U7.1
unnamed: R43.1, U7.10
unnamed: R44.1, U7.2
unnamed: R45.1, U7.3
unnamed: R46.2, U7.6
unnamed: R52.2, U1.37 (PB2/BOOT1/EVENTOUT)

Board: 4 copper layers, 67.0 x 50.0 mm, 128 parts (60 on the bottom side), 114 nets.
