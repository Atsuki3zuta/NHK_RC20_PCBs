# Repository Atsuki3zuta/NHK_RC20_PCBs

File README.md:

# NHK_RC20_PCBs
*[ROBO RUGBY 7s](https://www.aburobocon2020.com.fj/)*<br/>

## Summary
NHK大学学生ロボコン生活最後の基板(CADデータのみ)<br/>
開発期間諸々の関係上，結構チャレンジング精神満載のアートワークとなってしまってます…

## KiCad design MotorDriver/Brushed-DCMotor-Driver/CAN_DCMD_Normal_ver0/NormalMD.kicad_pcb

Parts:
AMP1, AMP2: TSC103; TSSOP-8_4.4x3mm_P0.65mm
C1, C3: 22p; C_0603_1608Metric
C2, C5, C6, C7, C8, C9, C11, C15, C16, C18, C21, C22, C24, C26, C27, C36, C38, C39, C42, C44, C51, C53, C54, C55, C58, C59, C60, C61: 0.1u; C_0603_1608Metric
C4, C17, C23, C40, C41, C52: 0.1u; 1608_WP
C10, C63: 1u; C_0603_1608Metric
C12: 4.7u; 1608_WP
C13, C14: 2.2u; C_0603_1608Metric
C19, C20, C30, C31, C45, C46, C48, C49: 4.7u; C_1206_3216Metric
C25, C33, C64: 100u; CP_Radial_D5.0mm_P2.50mm
C28: 10u; C_0805_2012Metric
C29, C32, C35, C37, C43: 4.7u; C_0805_2012Metric
C34: 1500u; C_Radial_D13.0mm_H25.0mm_P5.00mm
C56: 10u; C_0603_1608Metric
C57: 22u; C_0603_1608Metric
C62: 1u; 1608_WP
D1, D2, D3, D11, D13, D14, D19, D20: DIODE; 1608_WP
D4, D5, D6, D10, D16, D18, D24, D26: DIODE; D_SOD-123
D7: EMG1; LED_0603_1608Metric
D8: BUS1; LED_0603_1608Metric
D9: EMG0; LED_0603_1608Metric
D12: VALVE0; 1608_WP
D15: DIODE; D_SMA
D17: VALVE1; 1608_WP
D21: BATT; LED_0603_1608Metric
D22: 12VP; LED_0603_1608Metric
D23: 3V3P; LED_0603_1608Metric
D27: Main_BATT; LED_0603_1608Metric
D32: 12V; LED_0603_1608Metric
D33: 5V; LED_0603_1608Metric
D34: 3.3V; LED_0603_1608Metric
D39: BUS0; LED_0603_1608Metric
JP1: SWD_3V3; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP2: CAN_JP; PinHeader_1x02_P2.54mm_Vertical
JP3: I/O_Vdd; SW_Micro_SPST
L1, L2: 22uH; Inductor_Taiyo-Yuden_NR-60xx_HandSoldering
P1: SWD; ZH_6P
P2: VALVE; XA_4L
P3, P4: CAN; XA_4L
P5: SERIAL; XA_4P
P6: I/O_0; XA_3LC
P7: FAN; XA_2P
P8: BATT_IN; XT60_M
P9: BATT_IN; XT60_F
P10: OUT_1; XT60_F
P11: ENC_0; XA_4L
P13: ENC_1; XA_4L
P14: I/O_1; XA_3LC
P15: OUT_0; XT60_F
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: MOSFET_N; D2-PAK_compact
Q9, Q10: NPN; SOT-23W
R1, R4, R5, R9, R22: 10k; R_0603_1608Metric
R2, R10, R26, R27, R36, R39, R52, R61, R62, R66, R67, R68, R69, R70, R73, R74: 10k; 1608_WP
R3: 120; R_0603_1608Metric
R6, R7, R8, R49, R51: 330; R_0603_1608Metric
R11, R13, R35, R65: 100k; 1608_WP
R12: 330; 1608_WP
R14: 7.5k; R_0603_1608Metric
R15, R34, R48: 510; R_0603_1608Metric
R16, R32, R41: 4.7k; R_0603_1608Metric
R17, R18, R30, R31, R53, R54, R63, R64: FILTER; R_0603_1608Metric
R19, R20, R28, R29, R55, R56, R58, R59: 1; 1608_WP
R21, R24, R42, R43, R71, R72: 1k; 1608_WP
R23: 1k; R_0603_1608Metric
R25: 47; R_2812
R33: 2.2k; R_0603_1608Metric
R37: 3.9k; R_0603_1608Metric
R38: 680; R_0603_1608Metric
R40: 20k; R_0603_1608Metric
R44, R45, R46, R50: 4.7k; 1608_WP
R47: 1.2k; R_0603_1608Metric
R57, R60, R75, R76: 1m; R_2010_5025Metric
SW1: RST; SW_SPST_CK_RS282G05A3
SW3: SW0; SW_SPST_CK_RS282G05A3
SW4: SW1; SW_SPST_CK_RS282G05A3
TH1, TH2, TH3, TH4: Thermistor; 1608_WP
TH5: Thermistor; C_0603_1608Metric
U1: MAX3051; SOIC-8_3.9x4.9mm_P1.27mm
U2: BD9G101; TSOP-6_1.65x3.05mm_P0.95mm
U3: STM32F405RG; LQFP-64_10x10mm_P0.5mm
U4, U8, U12, U14: SI8274; SOIC-16_3.9x9.9mm_P1.27mm
U5: SI8900; SOIC-16W_7.5x10.3mm_P1.27mm
U6: ADC_~RST; SO-4_4.4x2.3mm_P1.27mm
U7: BD9G101G; TSOP-6_1.65x3.05mm_P0.95mm
U9: BD33FA1; SOT-89-3
U11: POWER_ON; SO-4_4.4x2.3mm_P1.27mm
U15: AZ1086H; SOT-223-3_TabPin2
U16: LOGO; Mini_Monster
U17: AQM0802; AQM0802_original
U19: ADRESS; rotary_0F
Y1: 8MHz; Crystal_SMD_5032_2Pads

Connections:
+3.3VP: AMP1.5 (VCC), AMP2.5 (VCC), C21.1, C22.1, C32.1, C36.1, R16.1, R34.2, U5.1 (VDDA), U5.2 (VREF), U9.1 (Vo)
+3V3: C4.1, C5.1, C6.1, C8.1, C9.1, C10.1, C12.1, C17.1, C40.1, C41.1, C42.1, C52.1, C57.1, C61.2, C62.2, D4.1 (K), JP3.1 (A), R9.1, R49.2, R73.1, R74.1, TH1.1, TH2.1, TH3.1, TH4.1, TH5.1, U1.3 (VDD), U3.1 (VBAT), U3.13 (VDDA), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U4.3 (VDDI), U4.8 (VDDI), U5.10 (VDDB), U5.16 (VDDB), U8.3 (VDDI), U8.8 (VDDI), U11.4, U12.3 (VDDI), U12.8 (VDDI), U14.3 (VDDI), U14.8 (VDDI), U15.2 (V_OUT), U17.5 (VDD), U17.9 (/RST)
+5V: C15.2, C26.2, C44.2, C56.1, D26.1 (K), JP3.3 (B), P5.2, P11.2, P13.2, R4.1, R5.1, R21.1, R24.1, R42.1, R43.1, R48.2, U15.3 (V_IN)
+12P: C29.1, C64.1, D18.1 (K), R19.1, R20.1, R28.1, R29.1, R33.2, R55.1, R56.1, R58.1, R59.1, U9.3 (Vcc)
+12V: C27.1, C33.1, C38.1, C51.1, D5.1 (K), P2.2, P2.4, R47.2, U2.4 (EN), U2.5 (IN)
+BATT: AMP1.8 (Vp), AMP2.8 (Vp), C34.1, C35.1, C43.1, D15.2 (A), P8.2, P9.2, R22.1, R32.2, R57.1, R60.1, R75.1, R76.1, U11.1
/ADC_~RST: R16.2, U5.7 (~RST~), U6.4
/ADC_~RST~_PIN: U3.45 (CAN1_TX/PA12), U6.1
/ADR_1: U3.23 (ADC12_IN7/TIM1_CH1N/TIM8_CH1N/TIM14_CH1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), U19.3 (1)
/ADR_2: U3.27 (ADC12_IN9/TIM1_CH3N/TIM8_CH3N/TIM3_CH4/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), U19.1 (2)
/ADR_4: U3.21 (ADC12_IN5/TIM2_CH1_ETR/TIM8_CH1N/PA5), U19.4
/ADR_8: U3.22 (ADC12_IN6/TIM3_CH1/TIM13_CH1/PA6), U19.6 (8)
/CAN1_RX: U1.4 (RXD), U3.61 (TIM4_CH3/TIM10_CH1/CAN1_RX/PB8)
/CAN1_TX: U1.1 (TXD), U3.62 (TIM4_CH4/TIM11_CH1/CAN1_TX/PB9)
/CAN_H: JP2.1, P3.3, P4.3, U1.7 (CANH)
/CAN_L: P3.4, P4.4, R3.1, U1.6 (CANL)
/CAN_Vdd: C7.2, C11.2, D5.2 (A), P3.2, P4.2
/Current0: AMP1.4 (Out), U5.5 (AIN2)
/Current1: AMP2.4 (Out), U5.4 (AIN1)
/EN0: R10.1, R36.1, U3.37 (PC6/TIM8_CH1/USART6_TX/TIM3_CH1), U4.5 (DISABLE), U12.5 (DISABLE)
/EN1: R2.1, R66.1, U3.34 (TIM1_CH1N/CAN2_TX/PB13), U8.5 (DISABLE), U14.5 (DISABLE)
/FB: R37.2, R38.1, U2.3 (FB)
/FB_PWR: C18.2, R14.2, R15.1, U7.3 (FB)
/FB_PWR_OUT: C18.1, C28.1, D18.2 (A), L1.2, R14.1
/I2C2_SCL: R73.2, U3.29 (USART3_TX/TIM2_CH3/PB10), U17.8 (SCL)
/I2C2_SDA: R74.2, U3.30 (USART3_RX/TIM2_CH4/PB11), U17.7 (SDA)
/IO_0: P6.3, U3.2 (PC13)
/IO_1: P14.3, U3.3 (PC14/OSC32_IN)
/LED0: R6.1, U3.52 (PC11/UART4_RX/USART3_RX)
/LED1: R7.1, U3.53 (PC12/UART5_TX)
/LED2: R8.1, U3.54 (PD2/UART5_RX)
/LED3: R51.1, U3.55 (TIM2_CH2/PB3)
/MOTOR0_BATT: AMP1.1 (Vm), Q1.D, Q5.D, R57.2, R60.2
/MOTOR1_BATT: AMP2.1 (Vm), Q3.D, Q7.D, R75.2, R76.2
/Motor0L_Tmp: C53.1, R67.1, TH1.2, U3.9 (PC1/ADC12_IN11)
/Motor0R_Tmp: C58.1, R52.1, TH3.2, U3.8 (PC0/ADC12_IN10)
/Motor1L_Tmp: C54.1, R68.1, TH2.2, U3.26 (ADC12_IN8/TIM1_CH2N/TIM8_CH2N/TIM3_CH3/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)
/Motor1R_Tmp: C59.1, R69.1, TH4.2, U3.25 (PC5/ADC12_IN15)
/OSC_IN: C1.2, U3.5 (OSC_IN), Y1.1
/OSC_OUT: C3.2, U3.6 (OSC_OUT), Y1.2
/OUT0_L: C19.2, P15.1, Q1.S, Q2.D, U4.14 (GNDA)
/OUT0_R: C30.2, P15.2, Q5.S, Q6.D, U12.14 (GNDA)
/OUT1_L: C45.2, P10.1, Q3.S, Q4.D, U8.14 (GNDA)
/OUT1_R: C48.2, P10.2, Q7.S, Q8.D, U14.14 (GNDA)
/PWM0_L: U3.38 (PC7/TIM8_CH2/USART6_RX/TIM3_CH2), U4.1 (PWM)
/PWM0_R: U3.39 (PC8/TIM8_CH3/TIM3_CH3), U12.1 (PWM)
/PWM1_L: U3.36 (TIM1_CH3N/TIM8_CH3N/TIM12_CH2/PB15), U8.1 (PWM)
/PWM1_R: U3.35 (TIM1_CH2N/TIM8_CH2N/TIM12_CH1/PB14), U14.1 (PWM)
/PWR_ON_PIN: R39.1, U3.44 (CAN1_RX/TIM1_CH4/PA11), U11.3
/SW0: R4.2, SW3.2, U3.41 (TIM1_CH1/PA8)
/SW1: R5.2, SW4.2, U3.40 (PC9/TIM8_CH4/TIM3_CH4)
/SWCLK: P1.3, U3.49 (SWCLK/PA14)
/SWDIO: P1.4, U3.46 (SWDIO/PA13)
/Substrate_Temp: C60.1, R70.1, TH5.2, U3.20 (ADC12_IN4/PA4)
/TIM3_CH1: R26.1, R44.2, U3.56 (TIM3_CH1/PB4)
/TIM3_CH2: R45.2, R61.1, U3.57 (CAN2_RX/TIM3_CH2/PB5)
/TIM4_CH1: R27.1, R46.2, U3.58 (TIM4_CH1/CAN2_TX/USART1_TX/PB6)
/TIM4_CH2: R50.2, R62.1, U3.59 (USART1_RX/TIM4_CH2/PB7)
/USART1_RX: U3.43 (USART1_RX/TIM1_CH3/PA10), U5.12 (TX)
/USART1_TX: U3.42 (USART1_TX/TIM1_CH2/PA9), U5.13 (RX)
/USART2_RX: P5.4, U3.17 (USART2_RX/TIM5_CH4/TIM9_CH2/ADC12_IN3/T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)
/USART2_TX: P5.3, U3.16 (USART2_TX/TIM5_CH3/TIM9_CH1/ADC12_IN2/T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)
/VALVE0: Q9.1 (B), R71.1, U3.50 (TIM2_CH1_ETR/PA15)
/VALVE1: Q10.1 (B), R72.1, U3.51 (PC10/UART4_TX/USART3_TX)
/Voltage: C24.1, R22.2, R23.1, U5.3 (AIN0)
/batt: C25.1, C37.1, D15.1 (K), R25.2, R41.2, U7.4 (EN), U7.5 (VCC)
/~RST: C2.2, P1.5, SW1.1, U3.7 (~RST)
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.1, C16.1, C17.2, C26.1, C27.2, C33.2, C38.2, C40.2, C41.2, C42.2, C44.1, C51.2, C52.2, C53.2, C54.2, C55.1, C56.2, C57.2, C58.2, C59.2, C60.2, C61.1, D6.2 (A), D7.1 (K), D8.1 (K), D9.1 (K), D10.2 (A), D12.1 (K), D17.1 (K), D24.2 (A), D32.1 (K), D33.1 (K), D34.1 (K), D39.1 (K), P1.1, P3.1, P4.1, P5.1, P6.1, P11.1, P13.1, P14.1, Q9.2 (E), Q10.2 (E), R1.2, R2.2, R10.2, R11.2, R12.2, R13.2, R26.2, R27.2, R35.2, R36.2, R38.2, R39.2, R52.2, R61.2, R62.2, R65.2, R66.2, R67.2, R68.2, R69.2, R70.2, SW1.2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
GNDPWR: AMP1.2 (SEL1), AMP1.3 (SEL2), AMP1.6 (GND), AMP1.7 (VCC-), AMP2.2 (SEL1), AMP2.3 (SEL2), AMP2.6 (GND), AMP2.7 (VCC-), C20.2, C21.2, C22.2, C24.2, C25.2, C28.2, C29.2, C31.2, C32.2, C34.2, C35.2, C36.2, C37.2, C43.2, C46.2, C49.2, C64.2, D16.2 (A), D21.1 (K), D22.1 (K), D23.1 (K), D27.1 (K), P7.1, P8.1, P9.1, Q2.S, Q4.S, Q6.S, Q8.S, R15.2, R23.2, R40.2, U4.9 (GNCB), U5.8 (GNDA), U6.3, U7.2 (GND), U8.9 (GNCB), U9.2 (FIN), U12.9 (GNCB), U14.9 (GNCB)
IO_Vdd: C16.2, C55.2, JP3.2 (C), P6.2, P14.2
unnamed: C13.1, U3.31 (VCAP_1)
unnamed: C14.1, U3.47 (VCAP_2)
unnamed: C19.1, D13.1 (K), U4.16 (VDDA)
unnamed: C20.1, D14.1 (K), U4.11 (VDDB)
unnamed: C23.1, D16.1 (K), L1.1, U7.6 (Lx)
unnamed: C23.2, U7.1 (BST)
unnamed: C30.1, D19.1 (K), U12.16 (VDDA)
unnamed: C31.1, D20.1 (K), U12.11 (VDDB)
unnamed: C39.1, D24.1 (K), L2.1, U2.6 (SW)
unnamed: C39.2, U2.1 (BS)
unnamed: C45.1, D1.1 (K), U8.16 (VDDA)
unnamed: C46.1, D2.1 (K), U8.11 (VDDB)
unnamed: C48.1, D3.1 (K), U14.16 (VDDA)
unnamed: C49.1, D11.1 (K), U14.11 (VDDB)
unnamed: C62.1, U17.2 (VOUT)
unnamed: C63.1, U17.3 (CAP1N)
unnamed: C63.2, U17.4 (CAP1P)
unnamed: D1.2 (A), R55.2
unnamed: D2.2 (A), R56.2
unnamed: D3.2 (A), R58.2
unnamed: D4.2 (A), JP1.2
unnamed: D6.1 (K), P2.1, Q9.3 (C)
unnamed: D7.2 (A), R6.2
unnamed: D8.2 (A), R7.2
unnamed: D9.2 (A), R8.2
unnamed: D10.1 (K), P2.3, Q10.3 (C)
unnamed: D11.2 (A), R59.2
unnamed: D12.2 (A), R71.2
unnamed: D13.2 (A), R19.2
unnamed: D14.2 (A), R20.2
unnamed: D17.2 (A), R72.2
unnamed: D19.2 (A), R28.2
unnamed: D20.2 (A), R29.2
unnamed: D21.2 (A), R32.1
unnamed: D22.2 (A), R33.1
unnamed: D23.2 (A), R34.1
unnamed: D26.2 (A), L2.2, R37.1
unnamed: D27.2 (A), R41.1
unnamed: D32.2 (A), R47.1
unnamed: D33.2 (A), R48.1
unnamed: D34.2 (A), R49.1
unnamed: D39.2 (A), R51.2
unnamed: JP1.1, P1.2
unnamed: JP2.2, R3.2
unnamed: P7.2, R25.1
unnamed: P11.3, R43.2, R45.1
unnamed: P11.4, R42.2, R44.1
unnamed: P13.3, R24.2, R50.1
unnamed: P13.4, R21.2, R46.1
unnamed: Q1.G, R17.1
unnamed: Q2.G, R18.1
unnamed: Q3.G, R53.1
unnamed: Q4.G, R54.1
unnamed: Q5.G, R30.1
unnamed: Q6.G, R31.1
unnamed: Q7.G, R63.1
unnamed: Q8.G, R64.1
unnamed: R1.1, U3.60 (BOOT0)
unnamed: R9.2, U3.28 (BOOT1/PB2)
unnamed: R11.1, U4.6 (DT)
unnamed: R12.1, U6.2
unnamed: R13.1, U8.6 (DT)
unnamed: R17.2, U4.15 (VOA)
unnamed: R18.2, U4.10 (VOB)
unnamed: R30.2, U12.15 (VOA)
unnamed: R31.2, U12.10 (VOB)
unnamed: R35.1, U12.6 (DT)
unnamed: R40.1, U11.2
unnamed: R53.2, U8.15 (VOA)
unnamed: R54.2, U8.10 (VOB)
unnamed: R63.2, U14.15 (VOA)
unnamed: R64.2, U14.10 (VOB)
unnamed: R65.1, U14.6 (DT)

Notes on the sheet:
TIM1CH
TIM8CH
Filter:10kohm
Filter:3ohm

Board: 2 copper layers, 75.0 x 88.0 mm, 224 parts (103 on the bottom side), 143 nets.
