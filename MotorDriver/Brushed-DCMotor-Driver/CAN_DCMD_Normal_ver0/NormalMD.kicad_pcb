# Repository Atsuki3zuta/NHK_RC20_PCBs (continued)

## KiCad design CAN_BLDCMD_type1/CAN_BLDCMD.kicad_pcb

Parts:
C1, C2: 22p; C_0603_1608Metric
C3, C4, C5, C7, C8, C11, C20, C22, C23, C24, C25, C26, C27, C40, C41, C43, C47: 0.1u; C_0603_1608Metric
C6, C9, C10, C14, C28, C31, C34, C35, C36, C42, C44, C45, C46, C51, C52, C53, C54, C59, C60: 0.1u; 1608_WP
C12, C18, C29, C30, C48, C55, C56, C57: 4.7u; C_0805_2012Metric
C13: 1u; C_0603_1608Metric
C15, C17: 2.2u; 1608_WP
C16: 4.7u; C_0603_1608Metric
C19: 10u; C_0603_1608Metric
C21: 22u; C_0603_1608Metric
C32, C33: 1u; 1608_WP
C37, C38, C39: 4.7u; C_1206_3216Metric
C49: 2200u; C_Radial_D13mm_H25.0mm_P5.00mm
C50, C58: 100u; CP_Radial_D5.0mm_P2.50mm
D1, D2, D3, D4, D7, D10, D11, D12, D14, D16, D22, D23: DIODE; D_SOD-123
D5: BUS; LED_0603_1608Metric
D6: EMG; LED_0603_1608Metric
D8: 12V; LED_0603_1608Metric
D9: 3.3V; LED_0603_1608Metric
D13: BATT; LED_0603_1608Metric
D15: DIODE; D_SMA
D17: MAIN_BATT; LED_0603_1608Metric
D18: 12VP; LED_0603_1608Metric
D19: 5VP; LED_0603_1608Metric
D20: 3V3P; 1608_WP
D21: MODE; LED_0603_1608Metric
D24: VALVE0; LED_0603_1608Metric
D25: VALVE1; LED_0603_1608Metric
F1: Polyfuse; Fuse_1812_4532Metric
J1: SWD; ZH_6P
J2, J3: CAN; XA_4L
J4: ENC; XA_4L
J5: I/O0; XA_3L
J6: I/O1; XA_3L
J7: SERIAL; PinSocket_1x04_P2.54mm_Vertical
J8: FAN; XA_2P
J9: BATT_IN; XT60_F
J10: BATT_IN; XT60_M
J11: OUT_U; SolderWirePad_1x01_Drill2.5mm
J12: OUT_V; SolderWirePad_1x01_Drill2.5mm
J13: OUT_W; SolderWirePad_1x01_Drill2.5mm
J14: HALL_IN; ZH_6P
J15: VALVE; XA_4L
JP1: SWD_JP; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP2: CAN_JP; PinHeader_1x02_P2.54mm_Vertical
JP3: I/O_Vdd; PinHeader_1x03_P2.54mm_Vertical
L1, L2: 22uH; Inductor_Taiyo-Yuden_NR-50xx_HandSoldering
Q1, Q2, Q3, Q4, Q5, Q6: MOSFET_N; HSOF-8-1
Q7, Q8: NPN; SOT-23
R1, R5, R6, R7, R11, R15, R16, R17, R18, R19, R22, R23, R24, R25, R26, R42, R48, R50, R52, R59: 10k; 1608_WP
R2: 3.9k; 1608_WP
R3: 680; 1608_WP
R4: 120; 1608_WP
R8, R9, R44, R54: 4.7k; 1608_WP
R10, R12, R43, R49, R51, R53, R56: 1k; 1608_WP
R13, R14, R21, R58, R60, R61: 330; 1608_WP
R20: 1.2k; 1608_WP
R27, R28, R29: 10; 1608_WP
R30, R31, R32, R33, R34, R35: FILTER; 1608_WP
R36, R37, R38, R39, R40, R41: 2m; R_2010_5025Metric
R45: 7.5k; 1608_WP
R46, R57: 510; 1608_WP
R47: 47; R_2812
R55: 2.2k; 1608_WP
SW1: SW0; SW_SPST_PTS810
SW2: SW1; SW_SPST_PTS810
SW3: MODE; SW_Micro_SPST
SW4: RST; SW_SPST_CK_RS282G05A3
TH1, TH2, TH3, TH4: Thermistor; 1608_WP
U1: BD33FA1; SOT-89-3
U2, U15: BD9G101G; TSOP-6_1.65x3.05mm_P0.95mm
U3: STM32F405RG; LQFP-64_10x10mm_P0.5mm
U4: AZ1086H; SOT-223-3_TabPin2
U5: ADRESS; rotary_0F
U6: ISO1050DUB; SOP-8_6.62x9.15mm_P2.54mm
U7: AQM0802; AQM0802_original
U8, U9, U10: NCP5104; SOIC-8_3.9x4.9mm_P1.27mm
U11, U12, U13: INA181; SOT-23-6
U16, U17: LTC2644; MSOP-12_3x4mm_P0.65mm
U19: LOGO; Mini_Monster
Y1: 8MHz; Crystal_SMD_5032_2Pads

Connections:
+3.3VP: C5.1, C6.1, C7.1, C11.1, C13.1, C14.1, C16.1, C31.2, C32.2, C42.1, C51.1, C52.1, C53.1, C54.1, C59.1, C60.1, D1.1 (K), D4.1 (K), JP3.3 (B), R7.1, R11.1, R15.1, R22.2, R23.2, R57.2, R59.1, TH1.1, TH2.1, TH3.1, TH4.1, U3.1 (VBAT), U3.13 (VDDA), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U6.1 (VCC1), U7.5 (VDD), U7.9 (/RST), U11.6 (V+), U12.6 (V+), U13.6 (V+), U16.1 (Vcc), U16.4 (IDLSEL), U16.5 (IOVcc), U16.7 (~PD), U16.10 (REF), U17.1 (Vcc), U17.4 (IDLSEL), U17.5 (IOVcc), U17.7 (~PD), U17.10 (REF)
+3V3: C3.1, C30.1, R21.2, U1.1 (Vo), U6.8 (VCC2)
+5VP: C19.1, C20.2, C24.1, F1.1, J4.2, J7.1, J14.6, JP3.1 (A), R10.2, R12.2, R56.2, U4.3 (V_IN)
+12P: C12.1, C58.1, D16.1 (K), J15.2, J15.4, R27.2, R28.2, R29.2, R55.2, U2.4 (EN), U2.5 (VCC)
+12V: C29.1, D3.1 (K), R20.2, U1.3 (Vcc)
+BATT: C49.1, C55.1, C57.1, D15.2 (A), J9.2, J10.2, Q1.D, Q3.D, Q5.D, R42.1, R44.2
+Batt: C48.1, C50.1, D15.1 (K), R47.2, R54.2, U15.4 (EN), U15.5 (VCC)
/ADRESS_0: U3.33 (CAN2_RX/PB12), U5.3 (1)
/ADRESS_1: U3.24 (PC4/ADC12_IN14), U5.1 (2)
/ADRESS_2: U3.34 (TIM1_CH1N/CAN2_TX/PB13), U5.4
/ADRESS_3: U3.35 (TIM1_CH2N/TIM8_CH2N/TIM12_CH1/PB14), U5.6 (8)
/CAN1_RX: U3.62 (TIM4_CH4/TIM11_CH1/CAN1_TX/PB9), U6.2 (RXD)
/CAN1_TX: U3.61 (TIM4_CH3/TIM10_CH1/CAN1_RX/PB8), U6.3 (TXD)
/CAN_H: J2.3, J3.3, R4.2, U6.7 (CANH); also elsewhere on the board
/CAN_L: J2.4, J3.4, JP2.2, U6.6 (CANL); also elsewhere on the board
/Drive_U_Temp: C25.1, R16.1, TH1.2, U3.21 (ADC12_IN5/TIM2_CH1_ETR/TIM8_CH1N/PA5)
/Drive_V_Temp: C26.1, R17.1, TH2.2, U3.22 (ADC12_IN6/TIM3_CH1/TIM13_CH1/PA6)
/Drive_W_Temp: C27.1, R18.1, TH3.2, U3.25 (PC5/ADC12_IN15)
/Enable: R24.1, R25.1, R26.1, U3.38 (PC7/TIM8_CH2/USART6_RX/TIM3_CH2), U8.3 (~SD), U9.3 (~SD), U10.3 (~SD)
/FB_5V: C4.1, C18.1, F1.2, L1.2, R2.1
/FB_12P: C43.2, C56.1, D16.2 (A), L2.2, R45.1
/HALL_0: J14.2, U3.55 (TIM2_CH2/PB3)
/HALL_1: J14.3, U3.59 (USART1_RX/TIM4_CH2/PB7)
/HALL_2: J14.4, U3.58 (TIM4_CH1/CAN2_TX/USART1_TX/PB6)
/I2C2_SCL: R22.1, U3.29 (USART3_TX/TIM2_CH3/PB10), U7.8 (SCL)
/I2C2_SDA: R23.1, U3.30 (USART3_RX/TIM2_CH4/PB11), U7.7 (SDA)
/IO0_Pin: J5.3, U3.3 (PC14/OSC32_IN)
/IO1_Pin: J6.3, U3.2 (PC13)
/LED0: R13.1, U3.9 (PC1/ADC12_IN11)
/LED1: R14.1, U3.10 (PC2/ADC12_IN12)
/LED2: R58.1, U3.11 (PC3/ADC12_IN13)
/OSC_IN: C1.1, U3.5 (OSC_IN), Y1.1
/OSC_OUT: C2.1, U3.6 (OSC_OUT), Y1.2
/OUT_U: C37.2, J11.1, Q1.S, Q2.D, R48.1, U8.6 (BRIDGE)
/OUT_U_Analog: U3.15 (UART4_RX/ADC12_IN1/TIM5_CH2/TIM2_CH2/PA1), U16.2 (VoutA)
/OUT_U_Current: U3.20 (ADC12_IN4/PA4), U11.1
/OUT_U_DIGITAL<3V3P: C44.1, R48.2, R49.1, U16.9 (INA)
/OUT_V: C38.2, J12.1, Q3.S, Q4.D, R50.1, U9.6 (BRIDGE)
/OUT_V_Analog: U3.16 (USART2_TX/TIM5_CH3/TIM9_CH1/ADC12_IN2/T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), U16.3 (VoutB)
/OUT_V_Current: U3.26 (ADC12_IN8/TIM1_CH2N/TIM8_CH2N/TIM3_CH3/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), U12.1
/OUT_V_DIGITAL<3V3P: C45.1, R50.2, R51.1, U16.8 (INB)
/OUT_W: C39.2, J13.1, Q5.S, Q6.D, R52.1, U10.6 (BRIDGE)
/OUT_W_Analog: U3.17 (USART2_RX/TIM5_CH4/TIM9_CH2/ADC12_IN3/T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), U17.2 (VoutA)
/OUT_W_Current: U3.27 (ADC12_IN9/TIM1_CH3N/TIM8_CH3N/TIM3_CH4/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), U13.1
/OUT_W_DIGITAL<3V3P: C46.1, R52.2, R53.1, U17.9 (INA)
/PWM_U: U3.40 (PC9/TIM8_CH4/TIM3_CH4), U8.2 (IN)
/PWM_V: U3.39 (PC8/TIM8_CH3/TIM3_CH3), U9.2 (IN)
/PWM_W: U3.37 (PC6/TIM8_CH1/USART6_TX/TIM3_CH1), U10.2 (IN)
/SW0: R7.2, SW1.2, U3.44 (CAN1_RX/TIM1_CH4/PA11)
/SW1: R11.2, SW2.2, U3.45 (CAN1_TX/PA12)
/SWCLK: J1.3, U3.49 (SWCLK/PA14)
/SWDIO: J1.4, U3.46 (SWDIO/PA13)
/SW_MODE: R59.2, SW3.2 (B)
/Subscribe_Temp: C28.1, R19.1, TH4.2, U3.23 (ADC12_IN7/TIM1_CH1N/TIM8_CH1N/TIM14_CH1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)
/TIMx_CH1: R5.2, R9.2, U3.56 (TIM3_CH1/PB4)
/TIMx_CH2: R6.2, R8.2, U3.57 (CAN2_RX/TIM3_CH2/PB5)
/USARTX_RX: J7.3, U3.43 (USART1_RX/TIM1_CH3/PA10)
/USARTX_TX: J7.4, U3.42 (USART1_TX/TIM1_CH2/PA9)
/VALVE0: Q7.1 (B), R60.1, U3.36 (TIM1_CH3N/TIM8_CH3N/TIM12_CH2/PB15)
/VALVE1: Q8.1 (B), R61.1, U3.41 (TIM1_CH1/PA8)
/VOLTAGE: C40.2, R42.2, R43.1, U3.14 (UART4_TX/TIM2_CH1_ETR/ADC12_IN0/TIM5_CH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)
/~RST: C41.1, J1.5, SW4.2, U3.7 (~RST)
GND: C3.2, C9.2, C10.2, C29.2, C30.2, D8.1 (K), D9.1 (K), J2.1, J3.1, U1.2 (FIN), U6.5 (GND2); also elsewhere on the board
GNDPWR: C1.2, C2.2, C5.2, C6.2, C7.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.2, C22.1, C23.1, C24.2, C25.2, C26.2, C27.2, C28.2, C31.1, C34.2, C35.2, C36.2, C40.1, C41.2, C42.2, C44.2, C45.2, C46.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, D2.2 (A), D5.1 (K), D6.1 (K), D13.1 (K), D14.2 (A), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.2 (A), D23.2 (A), D24.1 (K), D25.1 (K), J1.1, J4.1, J5.1, J6.1, J7.2, J8.1, J9.1, J10.1, J14.1, Q7.2 (E), Q8.2 (E), R1.2, R3.2, R5.1, R6.1, R16.2, R17.2, R18.2, R19.2, R24.2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
IO_Vdd: C22.2, C23.2, D7.1 (K), J5.2, J6.2
unnamed: C4.2, R2.2, R3.1, U2.3 (FB)
unnamed: C8.1, D2.1 (K), L1.1, U2.6 (Lx)
unnamed: C8.2, U2.1 (BST)
unnamed 68: C9.1, C10.1, D3.2 (A), J2.2, J3.2; also elsewhere on the board
unnamed: C15.1, U3.31 (VCAP_1)
unnamed: C17.1, U3.47 (VCAP_2)
unnamed: C21.1, D4.2 (A), U4.2 (V_OUT)
unnamed: C32.1, U7.2 (VOUT)
unnamed: C33.1, U7.3 (CAP1N)
unnamed: C33.2, U7.4 (CAP1P)
unnamed: C34.1, D10.2 (A), R27.1, U8.1 (Vcc)
unnamed: C35.1, D11.2 (A), R28.1, U9.1 (Vcc)
unnamed: C36.1, D12.2 (A), R29.1, U10.1 (Vcc)
unnamed: C37.1, D10.1 (K), U8.8 (VBOOT)
unnamed: C38.1, D11.1 (K), U9.8 (VBOOT)
unnamed: C39.1, D12.1 (K), U10.8 (VBOOT)
unnamed: C43.1, R45.2, R46.1, U15.3 (FB)
unnamed: C47.1, D14.1 (K), L2.1, U15.6 (Lx)
unnamed: C47.2, U15.1 (BST)
unnamed: D1.2 (A), JP1.2
unnamed: D5.2 (A), R13.2
unnamed: D6.2 (A), R14.2
unnamed: D7.2 (A), JP3.2 (C)
unnamed: D8.2 (A), R20.1
unnamed: D9.2 (A), R21.1
unnamed: D13.2 (A), R44.1
unnamed: D17.2 (A), R54.1
unnamed: D18.2 (A), R55.1
unnamed: D19.2 (A), R56.1
unnamed: D20.2 (A), R57.1
unnamed: D21.2 (A), R58.2
unnamed: D22.1 (K), J15.1, Q7.3 (C)
unnamed: D23.1 (K), J15.3, Q8.3 (C)
unnamed: D24.2 (A), R60.2
unnamed: D25.2 (A), R61.2
unnamed: J1.2, JP1.1
unnamed: J4.3, R8.1, R12.1
unnamed: J4.4, R9.1, R10.1
unnamed: J8.2, R47.1
unnamed: JP2.1, R4.1
unnamed: Q1.G, R30.1
unnamed: Q2.G, R31.1
unnamed: Q2.S, R36.1, R39.1, U11.3 (+)
unnamed: Q3.G, R32.1
unnamed: Q4.G, R33.1
unnamed: Q4.S, R37.1, R40.1, U12.3 (+)
unnamed: Q5.G, R34.1
unnamed: Q6.G, R35.1
unnamed: Q6.S, R38.1, R41.1, U13.3 (+)
unnamed: R1.1, U3.60 (BOOT0)
unnamed: R15.2, U3.28 (BOOT1/PB2)
unnamed: R30.2, U8.7 (DRV_HO)
unnamed: R31.2, U8.5 (DRV_LO)
unnamed: R32.2, U9.7 (DRV_HO)
unnamed: R33.2, U9.5 (DRV_LO)
unnamed: R34.2, U10.7 (DRV_HO)
unnamed: R35.2, U10.5 (DRV_LO)

Notes on the sheet:
FILTER : 3Ohm

Board: 2 copper layers, 70.0 x 75.0 mm, 202 parts (78 on the bottom side), 122 nets.

Other parts of the board:
J2#2: CAN; XA_4L

Their connections:
/CAN_H: J2#2.3; also elsewhere on the board
/CAN_L: J2#2.4; also elsewhere on the board
GND: J2#2.1; also elsewhere on the board
unnamed 68: J2#2.2; also elsewhere on the board

## KiCad design 工大祭MD/Kuge_MD/秋月縛り_出力落としたもの_片面/秋月縛り_片面.kicad_pcb

Parts:
C2, C3: 0.1u; C_0603_1608Metric
C4, C5: 4.7u; C_1210_3225Metric
C6: 470u; CP_Radial_D8.0mm_P3.50mm
D1, D3, D5, D6: DIODE; D_SOD-123
D2: LED; LED_D3.0mm_Clear
D4: DIODE; D_DO-34_SOD68_P7.62mm_Horizontal
D7: DIODE; D_SMA
J1: Conn_01x02; XA_2LC
P2: BATT; XT60_M
P3, P4: CONN_01X01; SolderWirePad_single_3mmDrill
P5: BATT; XT60_F
Q1, Q2, Q3, Q4: Q_NMOS_GDS; TO-220-3_Vertical
R5: 2.2k; R_0603_1608Metric
R7, R8: 10k; R_0603_1608Metric
R9, R11: 3; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R10, R12: 3; R_0603_1608Metric
U3, U4: IR2302; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+BATT: C6.1, D4.2 (A), D7.2 (A), P2.2, P5.2, R5.2
/MOTOR_BATT: D7.1 (K), Q1.2 (D), Q3.2 (D)
/OUT_L: C5.2, P4.1, Q3.3 (S), Q4.2 (D), U4.6 (Vs)
/OUT_R: C4.2, P3.1, Q1.3 (S), Q2.2 (D), U3.6 (Vs)
/PWM_L: D3.1 (K), U4.2 (IN)
/PWM_R: D1.1 (K), U3.2 (IN)
/batt: C2.1, C3.1, D4.1 (K), D5.2 (A), D6.2 (A), R7.1, R8.1, U3.1 (Vcc), U4.1 (Vcc)
GNDPWR: C2.2, C3.2, C6.2, D2.1 (K), P2.1, P5.1, Q2.3 (S), Q4.3 (S), U3.4 (COM), U4.4 (COM)
unnamed: C4.1, D5.1 (K), U3.8 (Vb)
unnamed: C5.1, D6.1 (K), U4.8 (Vb)
unnamed: D1.2 (A), J1.1
unnamed: D2.2 (A), R5.1
unnamed: D3.2 (A), J1.2
unnamed: Q1.1 (G), R9.1
unnamed: Q2.1 (G), R10.1
unnamed: Q3.1 (G), R11.1
unnamed: Q4.1 (G), R12.1
unnamed: R7.2, U3.3 (/SD)
unnamed: R8.2, U4.3 (/SD)
unnamed: R9.2, U3.7 (HO)
unnamed: R10.2, U3.5 (LO)
unnamed: R11.2, U4.7 (HO)
unnamed: R12.2, U4.5 (LO)

Board: 2 copper layers, 64.0 x 36.0 mm, 30 parts (16 on the bottom side), 23 nets.

## Commit log

2019-10-07 2019/10/07はここまで.(眠い)
2019-10-07 main基板のバージョン,一応上げた.
2019-10-23 加工データ(main)なんかミスっていたっぽい
2019-11-09 mainと電源が仮完成.
2019-11-11 RC20で使う基板のプロジェクトを作業用ディレクトリから移した.
2019-11-18 Complete control Voltage 40W ElectrocityManager
2019-11-27 test
2019-11-30 ステアMD作成
2019-12-01 Power MD仕様決定
2019-12-02 2019/12/02の進捗
2019-12-04 2019/12/04と2019/12/05の進捗
2019-12-07 MD関連
2019-12-08 2019/12/8
2019-12-11 進捗2019/12/12
2019-12-12 2019/12/12途中(内職)
2019-12-12 Power MD
2019-12-14 サーミスタのピンアサインの決定
2019-12-14 パワミMD
2019-12-17 NT中の進捗
2019-12-17 ピン配置王幅変更
2019-12-18 2019/12/18
2019-12-20 main基板のdcdc改善
2019-12-20 やる気がなくなった,ここまで
2019-12-21 MDにモータ駆動用のファンぽーとをつけた
2019-12-30 パワー系の配線完了かな
2019-12-30 2019/12/30
2019-12-31 2019/12/31
2020-01-01 また回路図的に仕様(?)を変更した
2020-01-04 2020/01/04
2020-01-05 2020/01/05
2020-01-06 2020/01/06
2020-01-08 2020/01/07の進捗
2020-01-08 MDの配線終わったぁぁぁぁぁぁぁぁぁぁぁぁぁぁぁ
2020-01-08 MDシルクを直した
2020-01-10 Power MD直した
2020-01-10 とちゅう
2020-01-18 ゲートドライバのフットプリントの幅,違うやんけgit add -A!
2020-01-18 少し改善(MD)
2020-01-22 ハイサイド電流センシングバージョンとローサイド電流センシングバージョン
2020-01-23 バージョン1
2020-01-26 normal MD構成大体固まった
2020-01-26 NormalMD途中
2020-01-27 Normal MD
2020-01-27 パワー部分の配置＆配線
2020-01-27 Normal MDとりあえず引き終わった
2020-01-27 主に製造ファイルの変更
2020-01-27 main基板のエンコーダ回路変更,その他回路図の追加
2020-01-27 electrocity -> electricity
2020-01-30 何変更したか忘れた
2020-01-31 BLDCの設計を進めた
2020-02-08 Main typeC化
2020-02-08 main基板の写真を追加
2020-02-09 BLDCそれなりに
2020-02-11 消えたBLDC復元
2020-02-13 ブラシレスの復元
2020-02-15 Power MD 電流センシングをローサイドでセンシングするように変更した&DAC乗っけた
2020-02-17 ブラシレス復元の続き
2020-02-17 CAN BLDCMD 本格設計開始
2020-02-17 CAN BLDC やる気が出たバージョンの設計開始
2020-02-21 だいぶ良いところまで進んだ
2020-02-21 ローサイドセンシングバージョンのMDも一応できた
2020-02-23 普通タイプのMD,はんだマスク忘れていたので入れた
2020-02-25 ねむねむ。( ˘ω˘)ｽﾔｧ
2020-02-26 電流制御MDをだいぶ進めた
2020-02-27 ぶざーてすときばんは頭悪い
2020-02-28 配置しただけで分かるやばいやつ
2020-02-29 もうちょいで電流制御MDの配線が終わる
2020-03-01 電流制御MD(仮)配線(仮)完成(仮)
2020-03-01 BLDCMD本格的に設計開始
2020-03-01 BLDC(仮)が形になってきた
2020-03-01 アンタレス
2020-03-02 電流制御MDシリアル通信ポート忘れていたので，追加した
2020-03-02 電流制御MD加工データ製造しただけ
2020-03-02 いろいろ修正しました
2020-03-02 電流制御MDのいらないフォルダを消した
2020-03-03 推奨->ThinkPad様に現在の進捗をいったんコミット
2020-03-04 BLDC type-1,配置のみ完了
2020-03-04 電源2種改良終わり，あとは外注する
2020-03-04 少し改良した
2020-03-05 MAIN基板，大体の構成完了．あとは配線を少し修正するのみ
2020-03-06 ブラシレスMD type1,完成が見えてきた
2020-03-06 main基板バージョン3回路図のみ完成
2020-03-06 電源基板とかの回路図変更していなかった気がする
2020-03-06 電源基板のシルク表記を直しただけ
2020-03-06 ピンアサイン表のエクセルファイルを消した．進捗git add -Agit add -A
2020-03-09 bldcmdもうちょい
2020-03-09 いろいろ修正した(なにやったけ? <-おい)
2020-03-10 BLDC type2引き終わった，基板にミスがあった
2020-03-10 またまたミス発見，直した
2020-03-11 CAN BLDCMD type1完成したが，とても強引
2020-03-11 GNDビア開けただけ
2020-03-16 BLDC 途中
2020-03-18 BLDCMD type0
2020-03-19 PowerMD，ビアが開いていないところがあったため，ビアを打った．
2020-03-23 電流制御用のMDのコンデンサの配置ミスがあったため，直した
2020-03-25 add project about Power-MD_ver.1.0-1 another edition
2020-03-25 change file's name: Power-Md ver1-1another
2020-03-27 Add project Power-MD ver.1.0 another-0
2020-03-28 ビアの開け方(この前ちらっとネット上で観測した開け方参考)により，放熱性能が上がるかチェックするMD作成
2020-04-01 can dc-md ver.1.2
2020-04-05 卍配 置 完 了卍
2020-04-06 main絶対動くマン
2020-04-06 メイン基板，ビア改良
2020-04-14 BLDCMD type2,ロータ位置推定回路修正
2020-04-26 3DCadデータ追加
2020-04-27 抵抗値を実装されているものに変更した
2020-05-02 MD,12V出力回路変更
2020-05-22 各基板，3DCAD化へ
2020-05-22 基板3D化たくさんしたつかれた
2020-05-23 add Power-MV_ver1-2 3DCADデータ
2020-05-27 DRV83xを使用したブラシレスMD，作ります
2020-05-31 メイン基板の3D化，本格的に始めます
2020-05-31 電源基板も随時3D化
2020-06-03 メイン基板の3D化続き
2020-06-07 電源基板ver.3.0の3D化&修正
2020-06-07 Power,Main for 3DCAD
2020-06-08 Add CAN BLDC-MD type3 ver.0.1
2020-06-08 メイン基板の3DCADデータ完成
2020-06-09 真・メイン基板の3DCADデータ
2020-06-09 電源基板の3DCAD作成，表面は大体完了
2020-06-16 電源基板の3DCAD化，めんどくさい…
2020-06-17 もうメイン基板は作らないぞという誓い(n回目)
2020-06-17 メイン基板ver.3.1の回路図出力した進捗
2020-06-20 3D続き
2020-06-20 電源基板(Iso-DCDC 60W)の3DCADようやく完成した
2020-07-03 推奨PCからの変更
2020-09-11 上げ忘れていた工大祭モータドライバ(前身開発基板)とJetsonNanoの電源基板関係
2020-09-11 上げ忘れていたけれど開発に大きくかかわったもの(工大祭モータドライバ)，実際に運用したものJetson Nano電源基板の追加
2020-09-12 ファイルの整理しました
2020-10-18 推奨のほうにファイルを追加しました
2020-10-25 電源基板(制御電源出力DCDC40Wバージョン)の3DCADデータ作成
2021-03-21 今更修正
