# Repository Atsuki3zuta/NHK_RC20_PCBs (continued)

## KiCad design Main/stm32f4_Centaurus_ver.3.1.1/stm32f4_Centaurus.kicad_pcb

Parts:
C1, C19, C22, C23, C29, C30, C34: 1u; C_0603
C2, C3, C4, C5, C8, C9, C10, C12, C14, C15, C16, C17, C18, C20, C21, C24, C25, C28, C32, C33, C36, C37, C38, C39, C40, C42: 0.1u; C_0603
C6, C7, C31: 10u; C_0603
C11, C13: 22p; C_0603
C26, C27: 2.2u; C_0603
C35: 4.7u; C_0603
D1: DATA; LED_0603
D2: COMM; LED_0603
D3: SERIAL1_TX; LED_0603
D4: SERIAL1_RX; LED_0603
D5: SERIAL1_ACTIVE; LED_0603
D6, D7, D8, D9, D10, D11, D12, D14, D15, D20, D26, D27, D28, D29, D32, D38, D39, D40, D41, D42: DIODE; SOD-123
D13: XA2_12V; LED_0603
D16: XA_5V; LED_0603
D17: 12V_to_5V; LED_0603
D18: BUS_5V; LED_0603
D19, D21, D22, D23, D24, D25, D33, D34: LED; LED_0603
D30: 5V; LED_0603
D31: 3V3; LED_0603
D35: XA4_12V; LED_0603
D36: CAN0_BUS; LED_0603
D37: CAN1_BUS; LED_0603
IC1: PIC24FJ64GB004; LQFP-44_10x10mm_Pitch0.8mm
J1: SERIAL1; USB_C_Receptacle_Palconn_UTC16-G
J2: EXTERNAL_~RST; XA_3T
JP1: CAN0_JP; Pin_Header_Straight_1x02
JP2: CAN1_JP; Pin_Header_Straight_1x02
JP3: SWD_3.3V_JP; GS2
JP4: PICKit_JP; GS2
JP5: I/O_Vdd; Pin_Header_Straight_1x03
JP6: RST_JP; PinHeader_1x02_P2.54mm_Vertical
L1: 22uH; Inductor_Taiyo-Yuden_NR-50xx_HandSoldering
LED1: RESET; TSHD
P1: PICKit3; ZH_6T
P2: ADVANCED_SBDBT; USB_A
P3: ENC0; XA_4T
P4: ENC2; XA_4T
P5: SPI0; XA_6T
P6: ENC3; XA_4T
P7: ENC1; XA_4T
P8: SERIAL4; XA_4T
P9: SERIAL3; XA_4T
P10: XA2_12V; XA_2T
P11: CAN0; XA_4T
P12: CAN1; XA_4T
P13: CAN0; XA_4LC
P14: CAN1; XA_4LC
P15: SERIAL2; XA_4T
P16: SERIAL0; XA_4T
P17: XA2_5V; XA_2T
P18: SWD; Pin_Header_Straight_1x05
P23: A/D; Pin_Header_Straight_1x10
P24: PWM; Pin_Header_Straight_1x10
P25: A/D_batt; Pin_Header_Straight_2x10
P26: PWM_batt; Pin_Header_Straight_2x10
P27: EMERGENCY_CHECK; XA_4LC
P28: I/O_5V; Pin_Header_Straight_1x04
P29: I/O_Variable; Pin_Header_Straight_1x04
P30: I/O_5V_batt; Pin_Header_Straight_2x04
P31: I/O_Variable; Pin_Header_Straight_2x04
Q1, Q2, Q3, Q6, Q8: FET_P; SOT-23
Q4, Q5: NPN; SOT-123
Q7: FET_N; SOT-23
R1, R12, R25, R26, R27, R28, R29, R30, R31, R32, R45, R50, R52, R54, R55, R56, R69, R70, R71, R73, R74, R75, R81: 10k; R_0603
R2, R3, R17, R22, R23, R24, R49, R57, R58, R59, R60, R61, R62, R63, R72: 330; R_0603
R4, R5, R6, R7, R13, R14, R15, R16, R82, R83: 4.7k; R_0603
R8, R9, R10, R11, R18, R19, R20, R21: 1k; R_0603
R33, R66, R67, R68: 1.2k; R_0603
R34, R37, R44, R65: 510; R_0603
R35: 3.9k; R_0603
R36: 680; R_0603
R38, R39: R_JP; R_0603
R40, R41, R43: 120; R_0603
R42, R51, R53: 10; R_0603
R46, R47, R48, R76: 330; 1608_WP
R64: 4.7k; 1608_WP
R77: 510; 1608_WP
R78, R79, R80: 10; 1608_WP
SP1: SPEAKER; PKLCS1212E4001
SW1: Main_POWER; SW_Micro_SPST
SW2: SW1; SW_SPST_PTS645
SW3: SW0; SW_SPST_PTS645
SW4: SW2; SW_SPST_PTS645
SW5: SW3; SW_SPST_PTS645
U1: STM32F407VG; TQFP-100_14x14mm_Pitch0.5mm
U2: AZ1086H
U3: MCP2221A; SOIC-14_3.9x8.7mm_Pitch1.27mm
U4: BD9G101G; TSOT-6-MK06A
U5, U6: MAX3051; SOIC-8_3.9x4.9mm_Pitch1.27mm
U7: AQM1602_BL; AQM1602_BL_Fad
U8: OSTBABS4C2B
U9: LOGO; Mini_Monster
U10: LOGO; kitLogo_Mask_5.0x5.0
U11: CPC1106N; SOP-4_3.8x4.1mm_P2.54mm
U12: PS7200K-1A; SOP-4_3.8x4.1mm_P2.54mm
U13: LOGO; Robocon2020_30.0x12.5_silk
X1: 8MHz; Crystal_SMD_5032_2Pads

Connections:
+3V3: C2.2, C3.1, C4.1, C7.1, C10.1, C20.2, C21.2, C28.2, C29.2, C31.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, D3.1 (A), D4.1 (A), D5.1 (A), D42.1 (A), IC1.10 (Vusb), IC1.17 (AVdd), IC1.28 (Vdd), IC1.40 (Vdd), JP3.1, JP4.1, JP5.1, P25.1, P25.3, P25.5, P25.7, P25.9, P25.11, P25.13, P25.15, P25.17, P25.19, R1.2, R2.1, R3.1, R12.2, R45.1, R50.1, R52.1, R54.1, R55.1, R56.1, R69.1, R72.2, U1.6 (VBAT), U1.11 (VDD), U1.19 (VDD), U1.21 (VREF+), U1.22 (VDDA), U1.28 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U2.2 (V_OUT), U3.1 (Vdd), U3.11 (Vusb), U5.3 (VCC), U6.3 (VCC), U7.5 (VDD), U7.9 (/RST), U7.10 (Anode), U12.4 (MOSFET)
+5V: C6.1, C8.2, C9.2, C14.2, C15.2, C16.2, C17.2, C24.2, C25.2, C32.2, IC1.42 (Vbus), JP5.3, P2.1 (VCC), P3.2, P4.2, P5.2, P6.2, P7.2, P8.2, P9.2, P15.2, P16.2, P26.1, P26.3, P26.5, P26.7, P26.9, P26.11, P26.13, P26.15, P26.17, P26.19, P30.1, P30.3, P30.5, P30.7, Q6.3 (D), R8.2, R9.2, R10.2, R11.2, R18.2, R19.2, R20.2, R21.2, R65.2, U2.3 (V_IN)
+12V: D6.2 (K), D29.1 (A), D41.1 (A), Q1.3 (D), Q8.1 (G), R81.1
/12V_TO_5V: C5.1, D10.1 (A), D15.2 (K), R37.2
/ADC12_IN2: P23.8, U1.25 (PA2/USART2_TX/TIM5_CH3/TIM9_CH1/TIM2_CH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)
/ADC12_IN3: P23.7, U1.26 (PA3/USART2_RX/TIM5_CH4/TIM9_CH2/TIM2_CH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)
/ADC12_IN4: P23.6, U1.29 (PA4/SPI1_NSS/SPI3_NSS/USART2_CK/DCMI_HS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)
/ADC12_IN5: P23.5, U1.30 (PA5/SPI1_SCK/OTG_HS_ULPI_CK/TIM2_CH1_ET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)
/ADC12_IN6: P23.4, U1.31 (PA6/SPI1_MISO/TIM8_BKIN/TIM13_CH1/DCMI_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)
/ADC12_IN9: P23.1, U1.36 (PB1/TIM3_CH4/TIM8_CH3N/OTG_HS_ULPI_D2/E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)
/ADC12_IN10: P23.10, U1.15 (PC0/OTG_HS_ULPI_STP/EVENTOUT)
/ADC12_IN11: P23.9, U1.16 (PC1/ETH_MDC/_EVENTOUT)
/ADC12_IN14: P23.3, U1.33 (PC4/ETH_RMII_RX_D0/ETH_MII_RX_D0/EVENTO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)
/ADC12_IN15: P23.2, U1.34 (PC5/ETH_RMII_RX_D1/ETH_MII_RX_D1/EVENTO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)
/BUS_5V: D12.1 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R44.2
/Buzzer_Vdd: D20.2 (K), D41.2 (K), Q8.3 (D), SP1.1
/CAN0_H: P11.3, P13.3, R40.1, U5.7 (CANH)
/CAN0_L: JP1.1, P11.4, P13.4, U5.6 (CANL)
/CAN1_H: P12.3, P14.3, R41.2, U6.7 (CANH)
/CAN1_L: JP2.2, P12.4, P14.4, U6.6 (CANL)
/CAN1_RX: U1.70 (PA11/USART1_CTS/CAN1_RX/TIM1_CH4_/OTG_F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), U5.4 (RXD)
/CAN1_TX: U1.71 (PA12/USART1_RTS/CAN1_TX/TIM1_ETR/OTG_FS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), U5.1 (TXD)
/CAN2_RX: U1.51 (PB12/SPI2_NSS/I2S2_WS/I2C2_SMBA/USART3_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), U6.4 (RXD)
/CAN2_TX: U1.52 (PB13/SPI2_SCK/I2S2_CK/USART3_CTS/TIM1_C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), U6.1 (TXD)
/CAN_BUS_12V: D7.1 (A), D38.2 (K), D39.2 (K)
/D+: IC1.8 (PGED2_D+_RP10_CN16_RB10), P2.3 (D+)
/D+_USB: J1.A6 (D+), J1.B6 (D+), U3.13 (D+)
/D-: IC1.9 (PGEC2_D-_RP11_CN15_RB11), P2.2 (D-)
/D-_USB: J1.A7 (D-), J1.B7 (D-), U3.12 (D-)
/EXTERNAL_~RST~_PIN: JP6.2, U11.4 (Loard)
/FB: R35.2, R36.1, U4.3 (FB)
/GP0: R22.2, U3.2 (GP0)
/GP1: R23.2, U3.3 (GP1)
/GP2: R24.2, U3.7 (GP2)
/I2C1_SCL: R52.2, U1.92 (PB6/I2C1_SCL/TIM4_CH1/CAN2_TX/DCMI_D5/U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), U7.8 (SCL)
/I2C1_SDA: R50.2, U1.93 (PB7/I2C1_SDA/FSMC_NL/DCMI_VSYNC/USART1_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), U7.7 (SDA)
/MCLR: IC1.18 (MCLR), P1.1, R1.1
/OSC_IN: C13.1, U1.12 (PH0/OSC_IN/EVENTOUT), X1.2
/OSC_OUT: C11.1, U1.13 (PH1/OSC_OUT/EVENTOUT), X1.1
/PA8: D23.1 (A), U1.67 (PA8/MCO1/USART1_CK/TIM1_CH1/I2C3_SCL/OT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)
/PB2: R42.2, U1.37 (PB2/BOOT1/EVENTOUT)
/PB11: Q7.3 (D), R69.2, U1.48 (PB11/I2C2_SDA/USART3_RX/OTG_HS_ULPI_D4/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)
/PC13: P28.3, U1.7 (PC13/EVENTOUT)
/PC14: P28.2, U1.8 (PC14/OSC32_IN/EVENTOUT)
/PC15: P28.1, U1.9 (PC15/OSC32_OUT/EVENTOUT)
/PD0: D25.1 (A), U1.81 (PD0/FSMC_D2/CAN1_RX/EVENTOUT)
/PD1: R54.2, SW3.2, U1.82 (PD1/FSMC_D3/CAN1_TX/EVENTOUT)
/PD3: R45.2, SW2.2, U1.84 (PD3/FSMC_CLK/USART2_CTS/EVENTOUT)
/PD4: R55.2, SW4.2, U1.85 (PD4/FSMC_NOE/USART2_RTS/EVENTOUT)
/PD7: R56.2, SW5.2, U1.88 (PD7/USART2_CK/FSMC_NE1/FSMC_NCE2/EVENTO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)
/PD10: D19.1 (A), U1.57 (PD10/FSMC_D15/USART3_CK/EVENTOUT)
/PD11: D21.1 (A), U1.58 (PD11/FSMC_CLE/FSMC_A16/USART3_CTS/EVENT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)
/PD14: D22.1 (A), U1.61 (PD14/FSMC_D0/TIM4_CH3/EVENTOUT/_EVENTOUT)
/PD15: D24.1 (A), U1.62 (PD15/FSMC_D1/TIM4_CH4/EVENTOUT)
/PE0: P29.4, U1.97 (PE0/TIM4_ETR/FSMC_NBL0/DCMI_D2/EVENTOUT)
/PE1: P29.3, U1.98 (PE1/FSMC_NBL1/DCMI_D3/EVENTOUT)
/PE2: P29.2, U1.1 (PE2/TRACECLK/FSMC_A23/ETH_MII_TXD3/EVEN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)
/PE3: P29.1, U1.2 (PE3/TRACED0/FSMC_A19/EVENTOUT)
/PE4: P28.4, U1.3 (PE4/TRACED1/FSMC_A20/DCMI_D4/EVENTOUT)
/PE7: D33.1 (A), U1.38 (PE7/FSMC_D4/TIM1_ETR/EVENTOUT)
/PE8: P5.6, U1.39 (PE8/FSMC_D5/TIM1_CH1N/EVENTOUT)
/PE10: R17.1, U1.41 (PE10/FSMC_D7/TIM1_CH2N/EVENTOUT)
/PE12: D34.1 (A), U1.43 (PE12/FSMC_D9/TIM1_CH3N/EVENTOUT)
/PE15: D26.1 (A), U1.46 (PE15/FSMC_D12/TIM1_BKIN/EVENTOUT)
/PGEC1: IC1.22 (PGEDC1_AN3_C2INA_RP1_CN5_RB1), P1.5
/PGED1: IC1.21 (PGED1_AN2_C2INB_RP0_CN4_RB0), P1.4
/RESET_SIGNAL: J2.3, U12.1 (Anode)
/SPI2_MISO: R79.2, U1.17 (PC2/SPI2_MISO/OTG_HS_ULPI_DIR/ETH_MII_T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)
/SPI2_MOSI: R78.2, U1.18 (PC3/SPI2_MOSI/I2S2_SD/OTG_HS_ULPI_NXT/E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)
/SPI2_SCK: R80.2, U1.47 (PB10/SPI2_SCK/I2S2_CK/I2C2_SCL/USART3_T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)
/ST-LINK_Vdd: D40.2 (K), JP3.2, U11.1 (+Control)
/SWCLK: P18.3, U1.76 (PA14/JTCK/SWCLK/EVENTOUT)
/SWDIO: P18.4, U1.72 (PA13/JTMS/SWDIO/EVENTOUT)
/TIM1_CH1: P24.4, U1.40 (PE9/FSMC_D6/TIM1_CH1/EVENTOUT)
/TIM1_CH2: P24.3, U1.42 (PE11/FSMC_D8/TIM1_CH2/EVENTOUT)
/TIM1_CH3: P24.2, U1.44 (PE13/FSMC_D10/TIM1_CH3/EVENTOUT)
/TIM1_CH4: P24.1, U1.45 (PE14/FSMC_D11/TIM1_CH4/EVENTOUT)
/TIM2_CH1: R5.2, R73.1, U1.77 (PA15/JTDI/SPI3_NSS/I2S3_WS/TIM2_CH1_ETR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)
/TIM2_CH2: R4.2, R70.1, U1.89 (PB3/JTDO/TRACESWO/SPI3_SCK/I2S3_CK/TIM2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)
/TIM3_CH1: R7.2, R29.1, U1.90 (PB4/NJTRST/SPI3_MISO/TIM3_CH1/SPI1_MISO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)
/TIM3_CH2: R6.2, R27.1, U1.91 (PB5/I2C1_SMBA/CAN2_RX/OTG_HS_ULPI_D7/ET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)
/TIM4_CH1: R16.2, R32.1, U1.59 (PD12/FSMC_ALE/FSMC_A17/TIM4_CH1/USART3_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)
/TIM4_CH2: R15.2, R31.1, U1.60 (PD13/FSMC_A18/TIM4_CH2/EVENTOUT)
/TIM5_CH1: R14.2, R75.1, U1.23 (PA0/WKUP/USART2_CTS/UART4_TX/ETH_MII_CR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)
/TIM5_CH2: R13.2, R74.1, U1.24 (PA1/USART2_RTS/UART4_RX/ETH_RMII_REF_CL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)
/TIM8_CH1: P24.6, U1.32 (PA7/SPI1_MOSI/TIM8_CH1N/TIM14_CH1/TIM3_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)
/TIM8_CH2: P24.5, U1.35 (PB0/TIM3_CH3/TIM8_CH2N/OTG_HS_ULPI_D1/E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)
/TIM8_CH3: U1.65 (PC8/TIM8_CH3/SDIO_D0/TIM3_CH3/USART6_CK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), U8.2 (green_A)
/TIM8_CH4: U1.66 (PC9/I2S_CKIN/MCO2/TIM8_CH4/SDIO_D1/I2C3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), U8.1 (blue_A)
/TIM9_CH1: P24.8, U1.4 (PE5/TRACED2/FSMC_A21/TIM9_CH1/DCMI_D6/E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)
/TIM9_CH2: P24.7, U1.5 (PE6/TRACED3_/_FSMC_A22/TIM9_CH2/DCMI_D7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)
/TIM10_CH1: P24.10, U1.95 (PB8/TIM4_CH3/SDIO_D4/TIM10_CH1/DCMI_D6/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)
/TIM11_CH1: P24.9, U1.96 (PB9/SPI2_NSS/I2S2_WS/TIM4_CH4/TIM11_CH1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)
/TIM12_CH1: R51.2, U1.53 (PB14/SPI2_MISO/TIM1_CH2N/TIM12_CH1/OTG_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)
/TIM12_CH2: U1.54 (PB15/SPI2_MOSI/I2S2_SD/TIM1_CH3N/TIM8_C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), U8.3 (red_A)
/UART4_RX: P9.4, U1.79 (PC11/UART4_RX/SPI3_MISO/SDIO_D3/DCMI_D4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)
/UART4_TX: P9.3, U1.78 (PC10/SPI3_SCK/I2S3_CK/UART4_TX/SDIO_D2/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)
/UART5_RX: P8.4, U1.83 (PD2/TIM3_ETR/UART5_RX/SDIO_CMD/DCMI_D11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)
/UART5_TX: P8.3, U1.80 (PC12/UART5_TX/SDIO_CK/DCMI_D9/SPI3_MOSI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)
/USART1_RX: P16.4, U1.69 (PA10/USART1_RX/TIM1_CH3/OTG_FS_ID/DCMI_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)
/USART1_TX: P16.3, U1.68 (PA9/USART1_TX/TIM1_CH2/I2C3_SMBA/DCMI_D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)
/USART2_RX: IC1.2 (RP22_CN18_RC6), U1.87 (PD6/FSMC_NWAIT/USART2_RX/EVENTOUT)
/USART2_TX: IC1.3 (RP23_CN17_RC7), U1.86 (PD5/FSMC_NWE/USART2_TX/EVENTOUT)
/USART3_RX: U1.56 (PD9/FSMC_D14/USART3_RX/EVENTOUT), U3.6 (UTx)
/USART3_TX: U1.55 (PD8/FSMC_D13/USART3_TX/EVENTOUT), U3.5 (URx)
/USART6_RX: P15.4, U1.64 (PC7/I2S3_MCK/TIM8_CH2/SDIO_D7/USART6_RX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)
/USART6_TX: P15.3, U1.63 (PC6/I2S2_MCK/TIM8_CH1/SDIO_D6/USART6_TX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)
/XA_12V: D6.1 (A), D8.2 (K), D32.2 (K), Q1.1 (G), R26.1
/~RST: C12.1, LED1.1, P18.5, U1.14 (NRST), U11.3 (Loard)
CAN0_BUS_Vdd: C22.2, D38.1 (A), P11.2, P13.2, R67.2
CAN1_BUS_Vdd: C23.2, D39.1 (A), P12.2, P14.2, R68.2
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.2, C12.2, C13.2, C14.1, C15.1, C16.1, C17.1, C19.2, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.2, C27.2, C28.1, C31.2, C32.1, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C42.1, D13.2 (K), D14.1 (A), D16.2 (K), D17.2 (K), D18.2 (K), D30.2 (K), D31.2 (K), D35.2 (K), D36.2 (K), D37.2 (K), IC1.6 (DISVREG), IC1.16 (AVss), IC1.29 (Vss), IC1.39 (Vss), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.1, LED1.2, LED1.4 (K), P1.3, P2.4 (GND), P3.1, P4.1, P5.1, P6.1, P7.1, P8.1, P9.1, P10.1, P11.1, P12.1, P13.1, P14.1, P15.1, P16.1, P17.1, P18.1, P25.2, P25.4, P25.6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
unnamed: C1.1, IC1.7 (Vcap_VddCore)
unnamed: C18.1, D14.2 (K), L1.1, U4.6 (SW)
unnamed: C18.2, U4.1 (BS)
unnamed: C19.1, D29.2 (K), U4.4 (EN), U4.5 (IN)
unnamed: C26.1, U1.49 (VCAP_1)
unnamed: C27.1, U1.73 (VCAP_2)
unnamed: C29.1, U7.2 (VOUT)
unnamed: C30.1, U7.3 (CAP1N)
unnamed: C30.2, U7.4 (CAP1P)
unnamed: D1.1 (A), R2.2
unnamed: D1.2 (K), IC1.14 (AN10_C3INB_CVref_VBUSON_RP14_CN12_RB14)
unnamed: D2.1 (A), R3.2
unnamed: D2.2 (K), IC1.15 (AN9_C3INA_VBUSCHG_RP15_CN11_RB15)
unnamed: D3.2 (K), R22.1
unnamed: D4.2 (K), R23.1
unnamed: D5.2 (K), R24.1
unnamed: D7.2 (K), Q1.2 (S)
unnamed: D10.2 (K), Q2.2 (S)
unnamed: D9.1 (A), D11.2 (K), Q2.1 (G), R28.1
unnamed: D12.2 (K), Q3.2 (S)
unnamed: D13.1 (A), R33.1
unnamed: D15.1 (A), L1.2, R35.1
unnamed: D16.1 (A), R34.1
unnamed: D17.1 (A), R37.1
unnamed: D18.1 (A), R44.1
unnamed: D19.2 (K), R49.1
unnamed: D20.1 (A), R53.1, SP1.2
unnamed: D21.2 (K), R57.1
unnamed: D22.2 (K), R58.1
unnamed: D23.2 (K), R59.1
unnamed: D24.2 (K), R60.1
unnamed: D25.2 (K), R61.1
unnamed: D26.2 (K), P27.3
unnamed: D9.2 (K), D27.1 (A), Q2.3 (D), Q3.1 (G), R30.1
unnamed: D27.2 (K), Q3.3 (D), Q6.2 (S), SW1.1
unnamed: D28.1 (A), P1.2
unnamed: D28.2 (K), JP4.2
unnamed: D30.1 (A), R65.1
unnamed: D31.1 (A), R72.1
unnamed: D33.2 (K), R62.1
unnamed: D34.2 (K), R63.1
unnamed: D35.1 (A), R66.1
unnamed: D36.1 (A), R67.1
unnamed: D37.1 (A), R68.1
unnamed: D40.1 (A), P18.2
unnamed: D42.2 (K), Q8.2 (S)
unnamed: J1.A5 (CC1), R83.1
unnamed: J1.B5 (CC2), R82.1
unnamed: JP1.2, R40.2
unnamed: JP2.1, R41.1
unnamed: JP5.2, P31.1, P31.3, P31.5, P31.7
unnamed: JP6.1, R64.1, U12.3 (MOSFET)
unnamed: LED1.3 (A), R17.2
unnamed: P3.3, R4.1, R10.1
unnamed: P3.4, R5.1, R8.1
unnamed: P4.3, R6.1, R11.1
unnamed: P4.4, R7.1, R9.1
unnamed: P5.3, R78.1
unnamed: P5.4, R79.1
unnamed: P5.5, R80.1
unnamed: P6.3, R13.1, R20.1
unnamed: P6.4, R14.1, R18.1
unnamed: P7.3, R15.1, R21.1
unnamed: P7.4, R16.1, R19.1
unnamed: P27.4, Q7.1 (G), R71.1
unnamed: Q4.1 (B), R51.1
unnamed: Q4.3 (C), R53.2
unnamed: Q5.1 (B), R42.1
unnamed: Q5.3 (C), R43.2
unnamed: Q6.1 (G), SW1.2
unnamed: R12.1, U3.4 (nRST)
unnamed: R25.1, U1.94 (BOOT0)
unnamed: R38.2, U5.8 (RS)
unnamed: R39.2, U6.8 (RS)
unnamed: R43.1, U7.11 (Kathode)
unnamed: R46.2, U8.6 (blue_K)
unnamed: R47.2, U8.5 (green_K)
unnamed: R48.2, U8.4 (red_K)
unnamed: R76.2, U12.2 (Kathode)
unnamed: R77.2, U11.2 (-Control)
XA2_5V: D11.1 (A), P17.2, R34.2
XA2_12V: D8.1 (A), P10.2, R33.2
XA4_12V: C42.2, D32.1 (A), P27.2, R66.2

Notes on the sheet:
PA12,11 -> can1.
Microcontroller Circuit
Power Supply Circuit
LOGOs
Functions
Power Check LEDs
CAN
SBDBT
Encoders
I/O,ADC,PWM,SPI
USB to Serial Converter
External Reset
http://akizukidenshi.com/catalog/g/gP-05723/
